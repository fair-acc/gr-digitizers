options:
  parameters:
    author: gsi
    generate_options: qt_gui
    id: signal_source_to_prepper_to_power_calc_to_sink
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '5'
    freq: '50'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: '50'
    offset: '0'
    phase: '0.5'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '2'
    type: float
  states: {}
- name: pulsed_power_daq_power_calc_ff_0
  id: pulsed_power_daq_power_calc_ff
  parameters:
    alpha: '0.0001'
  states: {}
- name: pulsed_power_daq_power_calc_ff_prepper_0
  id: pulsed_power_daq_power_calc_ff_prepper
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: P
    label2: Q
    label3: S
    label4: PHI
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: Phi
    label2: band pass current
    label3: band pass voltage
    label4: raw current
    label5: raw voltage
    nconnections: '5'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', pulsed_power_daq_power_calc_ff_prepper_0, '0']
- [analog_sig_source_x_0_0, '0', pulsed_power_daq_power_calc_ff_prepper_0, '1']
- [pulsed_power_daq_power_calc_ff_0, '0', qtgui_time_sink_x_0, '0']
- [pulsed_power_daq_power_calc_ff_0, '1', qtgui_time_sink_x_0, '1']
- [pulsed_power_daq_power_calc_ff_0, '2', qtgui_time_sink_x_0, '2']
- [pulsed_power_daq_power_calc_ff_0, '3', qtgui_time_sink_x_0, '3']
- [pulsed_power_daq_power_calc_ff_prepper_0, '0', pulsed_power_daq_power_calc_ff_0, '2']
- [pulsed_power_daq_power_calc_ff_prepper_0, '0', qtgui_time_sink_x_0_0, '0']
- [pulsed_power_daq_power_calc_ff_prepper_0, '1', pulsed_power_daq_power_calc_ff_0, '1']
- [pulsed_power_daq_power_calc_ff_prepper_0, '1', qtgui_time_sink_x_0_0, '1']
- [pulsed_power_daq_power_calc_ff_prepper_0, '2', pulsed_power_daq_power_calc_ff_0, '0']
- [pulsed_power_daq_power_calc_ff_prepper_0, '2', qtgui_time_sink_x_0_0, '2']
- [pulsed_power_daq_power_calc_ff_prepper_0, '3', blocks_null_sink_0, '0']
- [pulsed_power_daq_power_calc_ff_prepper_0, '3', qtgui_time_sink_x_0_0, '3']
- [pulsed_power_daq_power_calc_ff_prepper_0, '4', blocks_null_sink_0, '1']
- [pulsed_power_daq_power_calc_ff_prepper_0, '4', qtgui_time_sink_x_0_0, '4']

metadata:
  file_format: 1
