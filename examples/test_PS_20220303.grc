options:
  parameters:
    author: p01900
    generate_options: qt_gui
    id: test_PS_20220303
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: pulsed_power_daq_picoscope_4000a_source_0
  id: pulsed_power_daq_picoscope_4000a_source
  parameters:
    acquisition_mode: Rapid Block
    buff_size: '204800'
    coupling_ai_a: '1'
    coupling_ai_b: '1'
    coupling_ai_c: '0'
    coupling_ai_d: '0'
    coupling_ai_e: '0'
    coupling_ai_f: '0'
    coupling_ai_g: '0'
    coupling_ai_h: '0'
    downsampling_factor: '1'
    downsampling_mode: '0'
    driver_buff_size: '102400'
    enable_ai_a: 'True'
    enable_ai_b: 'True'
    enable_ai_c: 'False'
    enable_ai_d: 'False'
    enable_ai_e: 'False'
    enable_ai_f: 'False'
    enable_ai_g: 'False'
    enable_ai_h: 'False'
    nr_buffers: '64'
    nr_waveforms: '5'
    offset_ai_a: '0.0'
    offset_ai_b: '0.0'
    offset_ai_c: '5.0'
    offset_ai_d: '0.0'
    offset_ai_e: '0.0'
    offset_ai_f: '0.0'
    offset_ai_g: '5.0'
    offset_ai_h: '0.0'
    poll_rate: '0.0005'
    post_samples: '10000'
    pre_samples: '500000'
    range_ai_a: '5'
    range_ai_b: '1'
    range_ai_c: '5.0'
    range_ai_d: '5.0'
    range_ai_e: '5'
    range_ai_f: '5'
    range_ai_g: '5.0'
    range_ai_h: '5.0'
    samp_rate: samp_rate
    serial_number: ''
    trigger_direction: '0'
    trigger_once: 'False'
    trigger_source: None
    trigger_threshold: '2.5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '10'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '6'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [pulsed_power_daq_picoscope_4000a_source_0, '0', qtgui_time_sink_x_0, '0']
- [pulsed_power_daq_picoscope_4000a_source_0, '1', qtgui_time_sink_x_0, '1']
- [pulsed_power_daq_picoscope_4000a_source_0, '10', qtgui_time_sink_x_0_0, '0']
- [pulsed_power_daq_picoscope_4000a_source_0, '11', qtgui_time_sink_x_0_0, '1']
- [pulsed_power_daq_picoscope_4000a_source_0, '12', qtgui_time_sink_x_0_0, '2']
- [pulsed_power_daq_picoscope_4000a_source_0, '13', qtgui_time_sink_x_0_0, '3']
- [pulsed_power_daq_picoscope_4000a_source_0, '14', qtgui_time_sink_x_0_0, '4']
- [pulsed_power_daq_picoscope_4000a_source_0, '15', qtgui_time_sink_x_0_0, '5']
- [pulsed_power_daq_picoscope_4000a_source_0, '2', qtgui_time_sink_x_0, '2']
- [pulsed_power_daq_picoscope_4000a_source_0, '3', qtgui_time_sink_x_0, '3']
- [pulsed_power_daq_picoscope_4000a_source_0, '4', qtgui_time_sink_x_0, '4']
- [pulsed_power_daq_picoscope_4000a_source_0, '5', qtgui_time_sink_x_0, '5']
- [pulsed_power_daq_picoscope_4000a_source_0, '6', qtgui_time_sink_x_0, '6']
- [pulsed_power_daq_picoscope_4000a_source_0, '7', qtgui_time_sink_x_0, '7']
- [pulsed_power_daq_picoscope_4000a_source_0, '8', qtgui_time_sink_x_0, '8']
- [pulsed_power_daq_picoscope_4000a_source_0, '9', qtgui_time_sink_x_0, '9']

metadata:
  file_format: 1
