options:
  parameters:
    author: p01900
    comment: |-
      5001: raw

      5002: bp

      5003: power

      5004: mains freq

      5005: spectrum
    generate_options: qt_gui
    id: default
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '15'
    type: float
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: '4'
    type: float
  states: {}
- name: blocks_streams_to_vector_1
  id: blocks_streams_to_vector
  parameters:
    type: float
  states: {}
- name: blocks_streams_to_vector_2
  id: blocks_streams_to_vector
  parameters:
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '20'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: pulsed_power_daq_mains_frequency_calc_0
  id: pulsed_power_daq_mains_frequency_calc
  parameters:
    expected_sample_rate: samp_rate
    high_threshold: '100'
    low_threshold: '-100'
  states: {}
- name: pulsed_power_daq_picoscope_4000a_source_0
  id: pulsed_power_daq_picoscope_4000a_source
  parameters:
    acquisition_mode: Streaming
    buff_size: '204800'
    coupling_ai_a: '1'
    coupling_ai_b: '1'
    coupling_ai_c: '0'
    coupling_ai_d: '0'
    coupling_ai_e: '0'
    coupling_ai_f: '0'
    coupling_ai_g: '0'
    coupling_ai_h: '0'
    downsampling_factor: '1'
    downsampling_mode: '0'
    driver_buff_size: '102400'
    enable_ai_a: 'True'
    enable_ai_b: 'True'
    enable_ai_c: 'False'
    enable_ai_d: 'False'
    enable_ai_e: 'False'
    enable_ai_f: 'False'
    enable_ai_g: 'False'
    enable_ai_h: 'False'
    nr_buffers: '64'
    nr_waveforms: '5'
    offset_ai_a: '0.0'
    offset_ai_b: '0.0'
    offset_ai_c: '5.0'
    offset_ai_d: '0.0'
    offset_ai_e: '0.0'
    offset_ai_f: '0.0'
    offset_ai_g: '5.0'
    offset_ai_h: '0.0'
    poll_rate: '0.0005'
    post_samples: '10000'
    pre_samples: '500000'
    range_ai_a: '5'
    range_ai_b: '1'
    range_ai_c: '5.0'
    range_ai_d: '5.0'
    range_ai_e: '5'
    range_ai_f: '5'
    range_ai_g: '5.0'
    range_ai_h: '5.0'
    samp_rate: samp_rate
    serial_number: ''
    trigger_direction: '0'
    trigger_once: 'False'
    trigger_source: None
    trigger_threshold: '2.5'
  states: {}
- name: pulsed_power_daq_power_calc_ff_0
  id: pulsed_power_daq_power_calc_ff
  parameters:
    alpha: '0.0001'
  states: {}
- name: pulsed_power_daq_power_calc_ff_prepper_0
  id: pulsed_power_daq_power_calc_ff_prepper
  parameters: {}
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://10.0.0.2:5004
    timeout: '100'
    type: float
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://10.0.0.2:5001
    timeout: '100'
    type: float
    vlen: '2'
  states: {}
- name: zeromq_pub_sink_0_1
  id: zeromq_pub_sink
  parameters:
    address: tcp://10.0.0.2:5002
    timeout: '100'
    type: float
    vlen: '2'
  states: {}
- name: zeromq_pub_sink_0_2
  id: zeromq_pub_sink
  parameters:
    address: tcp://10.0.0.2:5005
    timeout: '100'
    type: float
  states: {}
- name: zeromq_pub_sink_0_6
  id: zeromq_pub_sink
  parameters:
    address: tcp://10.0.0.2:5003
    timeout: '100'
    type: float
    vlen: '4'
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', pulsed_power_daq_mains_frequency_calc_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_streams_to_vector_0, '0', zeromq_pub_sink_0_6, '0']
- [blocks_streams_to_vector_1, '0', zeromq_pub_sink_0_0, '0']
- [blocks_streams_to_vector_2, '0', zeromq_pub_sink_0_1, '0']
- [low_pass_filter_0, '0', zeromq_pub_sink_0_2, '0']
- [pulsed_power_daq_mains_frequency_calc_0, '0', zeromq_pub_sink_0, '0']
- [pulsed_power_daq_picoscope_4000a_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [pulsed_power_daq_picoscope_4000a_source_0, '0', pulsed_power_daq_power_calc_ff_prepper_0, '0']
- [pulsed_power_daq_picoscope_4000a_source_0, '1', blocks_null_sink_0, '0']
- [pulsed_power_daq_picoscope_4000a_source_0, '10', blocks_null_sink_0, '9']
- [pulsed_power_daq_picoscope_4000a_source_0, '11', blocks_null_sink_0, '10']
- [pulsed_power_daq_picoscope_4000a_source_0, '12', blocks_null_sink_0, '11']
- [pulsed_power_daq_picoscope_4000a_source_0, '13', blocks_null_sink_0, '12']
- [pulsed_power_daq_picoscope_4000a_source_0, '14', blocks_null_sink_0, '13']
- [pulsed_power_daq_picoscope_4000a_source_0, '15', blocks_null_sink_0, '14']
- [pulsed_power_daq_picoscope_4000a_source_0, '2', blocks_null_sink_0, '1']
- [pulsed_power_daq_picoscope_4000a_source_0, '2', pulsed_power_daq_power_calc_ff_prepper_0, '1']
- [pulsed_power_daq_picoscope_4000a_source_0, '3', blocks_null_sink_0, '2']
- [pulsed_power_daq_picoscope_4000a_source_0, '4', blocks_null_sink_0, '3']
- [pulsed_power_daq_picoscope_4000a_source_0, '5', blocks_null_sink_0, '4']
- [pulsed_power_daq_picoscope_4000a_source_0, '6', blocks_null_sink_0, '5']
- [pulsed_power_daq_picoscope_4000a_source_0, '7', blocks_null_sink_0, '6']
- [pulsed_power_daq_picoscope_4000a_source_0, '8', blocks_null_sink_0, '7']
- [pulsed_power_daq_picoscope_4000a_source_0, '9', blocks_null_sink_0, '8']
- [pulsed_power_daq_power_calc_ff_0, '0', blocks_streams_to_vector_0, '0']
- [pulsed_power_daq_power_calc_ff_0, '1', blocks_streams_to_vector_0, '1']
- [pulsed_power_daq_power_calc_ff_0, '2', blocks_streams_to_vector_0, '2']
- [pulsed_power_daq_power_calc_ff_0, '3', blocks_streams_to_vector_0, '3']
- [pulsed_power_daq_power_calc_ff_prepper_0, '0', pulsed_power_daq_power_calc_ff_0, '2']
- [pulsed_power_daq_power_calc_ff_prepper_0, '1', blocks_streams_to_vector_2, '0']
- [pulsed_power_daq_power_calc_ff_prepper_0, '1', pulsed_power_daq_power_calc_ff_0, '1']
- [pulsed_power_daq_power_calc_ff_prepper_0, '2', blocks_streams_to_vector_2, '1']
- [pulsed_power_daq_power_calc_ff_prepper_0, '2', pulsed_power_daq_power_calc_ff_0, '0']
- [pulsed_power_daq_power_calc_ff_prepper_0, '3', blocks_multiply_xx_0, '0']
- [pulsed_power_daq_power_calc_ff_prepper_0, '3', blocks_streams_to_vector_1, '0']
- [pulsed_power_daq_power_calc_ff_prepper_0, '4', blocks_multiply_xx_0, '1']
- [pulsed_power_daq_power_calc_ff_prepper_0, '4', blocks_streams_to_vector_1, '1']

metadata:
  file_format: 1
