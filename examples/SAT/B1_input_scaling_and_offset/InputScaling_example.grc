<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>B1_calibration</value></param>
<param><key>description</key><value>should be either static or BPC multiplexed</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>B.1)  Input Scaling and Offset</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cal</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>offset</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samples</value></param>
<param><key>value</key><value>2000</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0_0</value></param>
<param><key>amp</key><value>0.001</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>float</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>0.1</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_CONST_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>10</value></param>
<param><key>offset</key><value>0.1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SAW_WAVE</value></param>
</block>
<block>
<key>block_calibration</key>
<param><key>id</key><value>block_calibration_0</value></param>
<param><key>cal</key><value>cal</value></param>
<param><key>offset</key><value>offset</value></param>
</block>
<block>
<key>block_calibration</key>
<param><key>id</key><value>block_calibration_0_0</value></param>
<param><key>cal</key><value>cal</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>block_error_band</key>
<param><key>id</key><value>block_error_band_0</value></param>
</block>
<block>
<key>block_error_band</key>
<param><key>id</key><value>block_error_band_0_0</value></param>
</block>
<block>
<key>block_error_band</key>
<param><key>id</key><value>block_error_band_0_0_0</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digitizers_block_scaling_offset</key>
<param><key>id</key><value>digitizers_block_scaling_offset_0</value></param>
<param><key>offset</key><value>offset</value></param>
<param><key>scale</key><value>cal</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>-</value></param>
<param><key>style1</key><value>2</value></param>
<param><key>color2</key><value>"blue"</value></param>
<param><key>label2</key><value>input signal</value></param>
<param><key>color3</key><value>"blue"</value></param>
<param><key>label3</key><value>-</value></param>
<param><key>style3</key><value>2</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>samples</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>raw Amplitude</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>-0.5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>-</value></param>
<param><key>style1</key><value>2</value></param>
<param><key>color2</key><value>"blue"</value></param>
<param><key>label2</key><value>reference</value></param>
<param><key>color3</key><value>"blue"</value></param>
<param><key>label3</key><value>-</value></param>
<param><key>style3</key><value>2</value></param>
<param><key>color4</key><value>"red"</value></param>
<param><key>label4</key><value>-</value></param>
<param><key>style4</key><value>2</value></param>
<param><key>color5</key><value>"red"</value></param>
<param><key>label5</key><value>implementation under test</value></param>
<param><key>color6</key><value>"red"</value></param>
<param><key>label6</key><value>-</value></param>
<param><key>style6</key><value>2</value></param>
<param><key>nconnections</key><value>6</value></param>
<param><key>size</key><value>samples</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>cal Amplitude</value></param>
<param><key>ymax</key><value>15</value></param>
<param><key>ymin</key><value>-5</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>block_calibration_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>block_error_band_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>digitizers_block_scaling_offset_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>block_calibration_0</source_block_id><sink_block_id>block_error_band_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>block_calibration_0_0</source_block_id><sink_block_id>block_error_band_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>block_error_band_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>block_error_band_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>block_error_band_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>block_error_band_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>block_error_band_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>block_error_band_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>block_error_band_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>block_error_band_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>2</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>block_error_band_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>1</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>block_calibration_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>digitizers_block_scaling_offset_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>block_error_band_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_block_scaling_offset_0</source_block_id><sink_block_id>block_error_band_0_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_block_scaling_offset_0</source_block_id><sink_block_id>block_error_band_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
