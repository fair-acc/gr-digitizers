<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ps3000a_rapid_block_mode_test</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pre_samples</value></param>
<param><key>value</key><value>112</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>500000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samples</value></param>
<param><key>value</key><value>912</value></param>
</block>
<block>
<key>block_error_band</key>
<param><key>id</key><value>block_error_band_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>(samples+pre_samples)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>(samples+pre_samples)</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>delay</key><value>(samples+pre_samples)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>(samples+pre_samples)</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0_0</value></param>
<param><key>delay</key><value>(samples+pre_samples)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>(samples+pre_samples)</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0_0_0</value></param>
<param><key>delay</key><value>(samples+pre_samples)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>(samples+pre_samples)</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>4</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>4</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>(samples+pre_samples)</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>(samples+pre_samples)</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>(samples+pre_samples)</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digitizers_block_demux</key>
<param><key>id</key><value>digitizers_block_demux_0</value></param>
<param><key>bit_to_keep</key><value>0</value></param>
</block>
<block>
<key>digitizers_picoscope_3000a</key>
<param><key>id</key><value>digitizers_picoscope_3000a_0</value></param>
<param><key>acquisition_mode</key><value>Rapid Block</value></param>
<param><key>enable_ai_a</key><value>True</value></param>
<param><key>enable_ai_b</key><value>False</value></param>
<param><key>enable_ai_c</key><value>False</value></param>
<param><key>enable_ai_d</key><value>False</value></param>
<param><key>coupling_ai_a</key><value>True</value></param>
<param><key>coupling_ai_b</key><value>True</value></param>
<param><key>coupling_ai_c</key><value>True</value></param>
<param><key>coupling_ai_d</key><value>True</value></param>
<param><key>downsampling_factor</key><value>10</value></param>
<param><key>downsampling_mode</key><value>0</value></param>
<param><key>buff_size</key><value>10000</value></param>
<param><key>nr_waveforms</key><value>10000</value></param>
<param><key>pin_number</key><value>0</value></param>
<param><key>poll_rate</key><value>0.000</value></param>
<param><key>thresh_di_0</key><value>0.2</value></param>
<param><key>enable_di_0</key><value>True</value></param>
<param><key>thresh_di_1</key><value>0.5</value></param>
<param><key>enable_di_1</key><value>False</value></param>
<param><key>samples</key><value>samples</value></param>
<param><key>pre_samples</key><value>pre_samples</value></param>
<param><key>range_ai_a</key><value>1</value></param>
<param><key>range_ai_b</key><value>5</value></param>
<param><key>range_ai_c</key><value>5</value></param>
<param><key>range_ai_d</key><value>10</value></param>
<param><key>offset_ai_a</key><value>0</value></param>
<param><key>offset_ai_b</key><value>0.0</value></param>
<param><key>offset_ai_c</key><value>0.0</value></param>
<param><key>offset_ai_d</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>serial_number</key><value></value></param>
<param><key>trigger_direction</key><value>0</value></param>
<param><key>trigger_once</key><value>True</value></param>
<param><key>trigger_source</key><value>Digital</value></param>
<param><key>trigger_threshold</key><value>0.04</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>-</value></param>
<param><key>style1</key><value>2</value></param>
<param><key>color2</key><value>"blue"</value></param>
<param><key>label2</key><value>channel A</value></param>
<param><key>color3</key><value>"blue"</value></param>
<param><key>label3</key><value>-</value></param>
<param><key>style3</key><value>2</value></param>
<param><key>name</key><value>"Raw Data"</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>10*(samples+pre_samples)</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_level</key><value>0.1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.5</value></param>
<param><key>ymax</key><value>5</value></param>
<param><key>ymin</key><value>-5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>0,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>label1</key><value>D0</value></param>
<param><key>marker1</key><value>1</value></param>
<param><key>name</key><value>"Trigger Port"</value></param>
<param><key>size</key><value>10*(samples+pre_samples)</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.5</value></param>
<param><key>ylabel</key><value>Decimal nr.</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>-0.5</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>-</value></param>
<param><key>color2</key><value>"blue"</value></param>
<param><key>label2</key><value>triggered</value></param>
<param><key>color3</key><value>"blue"</value></param>
<param><key>label3</key><value>-</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>(samples+pre_samples)</value></param>
<param><key>x_axis_label</key><value>triggered time axis</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>(samples+pre_samples)</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>-0.1</value></param>
<param><key>y_axis_label</key><value>amplitude</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0_0</value></param>
<param><key>gui_hint</key><value>1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>block#5</value></param>
<param><key>label2</key><value>block#4</value></param>
<param><key>label3</key><value>block#3</value></param>
<param><key>label4</key><value>block#2</value></param>
<param><key>color5</key><value>"magenta"</value></param>
<param><key>label5</key><value>block#1</value></param>
<param><key>nconnections</key><value>5</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>(samples+pre_samples)</value></param>
<param><key>x_axis_label</key><value>triggered time axis</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>(samples+pre_samples)</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>-0.1</value></param>
<param><key>y_axis_label</key><value>amplitude</value></param>
</block>
<connection><source_block_id>block_error_band_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>block_error_band_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>block_error_band_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>block_error_band_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>block_error_band_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>block_error_band_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>blocks_delay_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_0</source_block_id><sink_block_id>blocks_delay_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>block_error_band_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_block_demux_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>4</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>6</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>block_error_band_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>3</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>5</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>7</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>blocks_null_sink_0_1</sink_block_id><source_key>8</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>digitizers_block_demux_0</sink_block_id><source_key>8</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>blocks_null_sink_0_1</sink_block_id><source_key>9</source_key><sink_key>1</sink_key></connection>
</flow_graph>
