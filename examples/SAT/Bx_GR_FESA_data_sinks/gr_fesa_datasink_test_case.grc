<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>GR_FESA_sinks</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_tag_object</key>
<param><key>id</key><value>edge_detect_1</value></param>
<param><key>key</key><value>pmt.intern("edge_detect")</value></param>
<param><key>offset</key><value>4101</value></param>
<param><key>src</key><value>pmt.intern("src")</value></param>
<param><key>value</key><value>pmt.make_tuple(pmt.from_bool(True), pmt.from_uint64(2000000000), pmt.from_uint64(2000000000), pmt.from_uint64(0), pmt.from_uint64(0))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nbins</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nbins_triggered</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nsamples</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nsamples__triggered</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>variable_tag_object</key>
<param><key>id</key><value>wr_tag</value></param>
<param><key>key</key><value>pmt.intern("wr_event")</value></param>
<param><key>offset</key><value>4100</value></param>
<param><key>src</key><value>pmt.intern("src")</value></param>
<param><key>value</key><value>pmt.make_tuple(pmt.string_to_symbol('foo'), pmt.from_uint64(2000000000), pmt.from_uint64(1900000000), pmt.from_bool(False), pmt.from_bool(True))</value></param>
</block>
<block>
<key>analog_fastnoise_source_x</key>
<param><key>id</key><value>analog_fastnoise_source_x_0</value></param>
<param><key>amp</key><value>0.05</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>float</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>samples</key><value>10000</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>2200</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SQR_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>4400</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_TRI_WAVE</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>3</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>[1.0/nbins] * nbins</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>nbins</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0</value></param>
<param><key>const</key><value>[1.0/nbins_triggered] * nbins_triggered</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>nbins_triggered</value></param>
</block>
<block>
<key>blocks_multiply_const_xx</key>
<param><key>id</key><value>blocks_multiply_const_xx_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>vlen</key><value>nbins</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>20</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0_0</value></param>
<param><key>vlen</key><value>nbins_triggered</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>20</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>nbins</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>nbins_triggered</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_tags_strobe</key>
<param><key>id</key><value>blocks_tags_strobe_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>key</key><value>pmt.intern("acq_info")</value></param>
<param><key>nsamps</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>value</key><value>pmt.make_tuple(pmt.from_uint64(10000), pmt.from_double(1.0/samp_rate), pmt.from_double(0.0), pmt.from_double(0.0), pmt.from_long(0), pmt.from_long(0), pmt.from_long(0), pmt.from_uint64(0), pmt.from_uint64(5000), pmt.from_bool(True))</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>tags</key><value>[wr_tag, edge_detect_1]</value></param>
<param><key>vector</key><value>([0] *8192) </value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>nbins_triggered</value></param>
</block>
<block>
<key>digitizers_demux_ff</key>
<param><key>id</key><value>digitizers_demux_ff_0</value></param>
<param><key>history</key><value>nsamples__triggered+100000</value></param>
<param><key>post_trigger_window</key><value>nsamples__triggered</value></param>
<param><key>pre_trigger_window</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>digitizers_demux_ff</key>
<param><key>id</key><value>digitizers_demux_ff_0_0</value></param>
<param><key>history</key><value>nbins_triggered*2+100000</value></param>
<param><key>post_trigger_window</key><value>nbins_triggered*2</value></param>
<param><key>pre_trigger_window</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>digitizers_freq_sink_f</key>
<param><key>id</key><value>digitizers_freq_sink_f_0</value></param>
<param><key>acquisition_type</key><value>1</value></param>
<param><key>nbuffers</key><value>1</value></param>
<param><key>nmeasurements</key><value>10</value></param>
<param><key>nbins</key><value>nbins</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>signal_name</key><value>My Signal</value></param>
</block>
<block>
<key>digitizers_freq_sink_f</key>
<param><key>id</key><value>digitizers_freq_sink_f_0_0</value></param>
<param><key>acquisition_type</key><value>0</value></param>
<param><key>nbuffers</key><value>1</value></param>
<param><key>nmeasurements</key><value>10</value></param>
<param><key>nbins</key><value>nbins_triggered</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>signal_name</key><value>My Signal</value></param>
</block>
<block>
<key>digitizers_post_mortem_sink</key>
<param><key>id</key><value>digitizers_post_mortem_sink_0</value></param>
<param><key>buffer_size</key><value>1000000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>signal_name</key><value>Signal_name</value></param>
<param><key>signal_unit</key><value>[a.u.]</value></param>
</block>
<block>
<key>digitizers_stft_algorithms</key>
<param><key>id</key><value>digitizers_stft_algorithms_0</value></param>
<param><key>alg_id</key><value>0</value></param>
<param><key>delta_t</key><value>0.02</value></param>
<param><key>fq_low</key><value>0.0</value></param>
<param><key>nbins</key><value>512</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>fq_hi</key><value>samp_rate/2</value></param>
<param><key>win_type</key><value>firdes.WIN_HANN</value></param>
<param><key>win_size</key><value>nbins</value></param>
</block>
<block>
<key>digitizers_stft_algorithms</key>
<param><key>id</key><value>digitizers_stft_algorithms_0_0</value></param>
<param><key>alg_id</key><value>0</value></param>
<param><key>delta_t</key><value>0.01</value></param>
<param><key>fq_low</key><value>0.0</value></param>
<param><key>nbins</key><value>512</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>fq_hi</key><value>samp_rate/2</value></param>
<param><key>win_type</key><value>firdes.WIN_HANN</value></param>
<param><key>win_size</key><value>nbins_triggered</value></param>
</block>
<block>
<key>digitizers_time_domain_sink</key>
<param><key>id</key><value>digitizers_time_domain_sink_0</value></param>
<param><key>buffer_size</key><value>nsamples__triggered</value></param>
<param><key>acquisition_type</key><value>0</value></param>
<param><key>nr_buffers</key><value>16</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>signal_name</key><value>test_signal</value></param>
<param><key>signal_unit</key><value>a.u.</value></param>
</block>
<block>
<key>digitizers_time_domain_sink</key>
<param><key>id</key><value>digitizers_time_domain_sink_0_0</value></param>
<param><key>buffer_size</key><value>10000</value></param>
<param><key>acquisition_type</key><value>0</value></param>
<param><key>nr_buffers</key><value>16</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>signal_name</key><value>test_signal</value></param>
<param><key>signal_unit</key><value>a.u.</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0</value></param>
<param><key>gui_hint</key><value>1,3</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>zmax</key><value>-20</value></param>
<param><key>zmin</key><value>-60</value></param>
<param><key>ncols</key><value>nbins_triggered</value></param>
<param><key>nrows</key><value>20</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>gui_hint</key><value>0,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>Triggered Time-Domain</value></param>
<param><key>size</key><value>nsamples__triggered</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.1</value></param>
<param><key>ymin</key><value>-0.1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>Continuous Time-Domain</value></param>
<param><key>size</key><value>nsamples</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.1</value></param>
<param><key>ymin</key><value>-0.1</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>Goertzel </value></param>
<param><key>width1</key><value>2</value></param>
<param><key>name</key><value>Continuous Frequency-Domain</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>nbins</value></param>
<param><key>x_axis_label</key><value>"norm. frequency [samp_rate]"</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>0.5/nbins</value></param>
<param><key>x_units</key><value>"samp_rate"</value></param>
<param><key>ymax</key><value>5</value></param>
<param><key>ymin</key><value>-75</value></param>
<param><key>y_axis_label</key><value>"amplitude [dB]"</value></param>
<param><key>y_units</key><value>"[dB]"</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>Goertzel </value></param>
<param><key>width1</key><value>2</value></param>
<param><key>name</key><value>Triggerd Frequency-Domain</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>update_time</key><value>0.1</value></param>
<param><key>vlen</key><value>nbins_triggered</value></param>
<param><key>x_axis_label</key><value>"norm. frequency [samp_rate]"</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>0.5/nbins</value></param>
<param><key>x_units</key><value>"samp_rate"</value></param>
<param><key>ymax</key><value>5</value></param>
<param><key>ymin</key><value>-75</value></param>
<param><key>y_axis_label</key><value>"amplitude [dB]"</value></param>
<param><key>y_units</key><value>"[dB]"</value></param>
</block>
<connection><source_block_id>analog_fastnoise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>blocks_nlog10_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_xx_0</source_block_id><sink_block_id>digitizers_demux_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_xx_0</source_block_id><sink_block_id>digitizers_stft_algorithms_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>digitizers_post_mortem_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_null_source_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_tags_strobe_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>digitizers_post_mortem_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_demux_ff_0</source_block_id><sink_block_id>digitizers_time_domain_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_demux_ff_0</source_block_id><sink_block_id>digitizers_time_domain_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_demux_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_demux_ff_0_0</source_block_id><sink_block_id>digitizers_stft_algorithms_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_post_mortem_sink_0</source_block_id><sink_block_id>digitizers_demux_ff_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_post_mortem_sink_0</source_block_id><sink_block_id>digitizers_time_domain_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_post_mortem_sink_0</source_block_id><sink_block_id>blocks_multiply_const_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_post_mortem_sink_0</source_block_id><sink_block_id>digitizers_demux_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_post_mortem_sink_0</source_block_id><sink_block_id>digitizers_time_domain_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_post_mortem_sink_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_stft_algorithms_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_stft_algorithms_0</source_block_id><sink_block_id>digitizers_freq_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_stft_algorithms_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_stft_algorithms_0</source_block_id><sink_block_id>digitizers_freq_sink_f_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>digitizers_stft_algorithms_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_stft_algorithms_0</source_block_id><sink_block_id>digitizers_freq_sink_f_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_stft_algorithms_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_stft_algorithms_0_0</source_block_id><sink_block_id>digitizers_freq_sink_f_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_stft_algorithms_0_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_stft_algorithms_0_0</source_block_id><sink_block_id>digitizers_freq_sink_f_0_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>digitizers_stft_algorithms_0_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_stft_algorithms_0_0</source_block_id><sink_block_id>digitizers_freq_sink_f_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
</flow_graph>
