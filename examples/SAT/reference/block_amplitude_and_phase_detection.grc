<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ampl_phase_detector</value></param>
<param><key>author</key><value>rstein</value></param>
<param><key>category</key><value>[digitizerRef]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>B.5 Amplitude &amp; Phase Detector</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TWO_PI</value></param>
<param><key>value</key><value>6.28318530718</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>algorithm_id</value></param>
<param><key>label</key><value>Algorithm ID</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_magphase</key>
<param><key>id</key><value>blocks_complex_to_magphase_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>360.0/TWO_PI</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decimation</value></param>
<param><key>label</key><value>Decimation</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fir_taps_user</value></param>
<param><key>label</key><value>FIR Taps User</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_max</value></param>
<param><key>label</key><value>Upper Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_min</value></param>
<param><key>label</key><value>Lower Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_transition</value></param>
<param><key>label</key><value>Transition Width</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hilbert_taps</value></param>
<param><key>label</key><value>N Hilbert Filter Taps</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>iir_feedback_Taps</value></param>
<param><key>label</key><value>IIR Feedback Taps User</value></param>
<param><key>value</key><value>()</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>iir_forward_Taps</value></param>
<param><key>label</key><value>IIR Forward Taps User</value></param>
<param><key>value</key><value>()</value></param>
</block>
<block>
<key>iq_down_converter</key>
<param><key>id</key><value>iq_down_converter_0</value></param>
<param><key>algorithm_id</key><value>algorithm_id</value></param>
<param><key>decimation</key><value>decimation</value></param>
<param><key>fir_taps_user</key><value>fir_taps_user</value></param>
<param><key>iir_feedback_Taps</key><value>iir_feedback_Taps</value></param>
<param><key>iir_forward_Taps</key><value>iir_forward_Taps</value></param>
<param><key>freq_min</key><value>freq_min</value></param>
<param><key>hilbert_taps</key><value>hilbert_taps</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>freq_transition</key><value>freq_transition</value></param>
<param><key>freq_max</key><value>freq_max</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>ampl</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_3</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>phase</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>ref</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<connection><source_block_id>blocks_complex_to_magphase_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_magphase_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>pad_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iq_down_converter_0</source_block_id><sink_block_id>blocks_complex_to_magphase_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>iq_down_converter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>iq_down_converter_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
