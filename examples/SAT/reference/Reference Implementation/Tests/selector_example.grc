<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>selector_example</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>IIR_feedback_0</value></param>
<param><key>value</key><value>1.0, -4.883632384956582, 9.54127151717133, -9.321780090620553, 4.554280419089137, -0.890139403919765</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>IIR_feedback_1</value></param>
<param><key>value</key><value>1.0, -7.586357084563112, 26.131288821609992, -53.77540761007004, 73.16941578692908, -68.74321606884482, 45.14084094501371, -20.44899972126457, 6.113672770121455, -1.0889392670519782, 0.08772116891632613</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>IIR_feedforward_0</value></param>
<param><key>value</key><value>1.7738613342568748e-09, 8.86930667128439e-09, 1.773861334256881e-08, 1.7738613342568837e-08, 8.869306671284435e-09, 1.773861334256889e-09</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>IIR_feedforward_1</value></param>
<param><key>value</key><value>1.927812121365849e-08, 1.9278121213658484e-07, 8.675154546146312e-07, 2.313374545639017e-06, 4.0484054548682805e-06, 4.858086545841939e-06, 4.048405454868283e-06, 2.3133745456390203e-06, 8.675154546146333e-07, 1.9278121213658535e-07, 1.9278121213658454e-08</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>algorithm_ID</value></param>
<param><key>value</key><value>4</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label</key><value>Algorithm ID</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>5</value></param>
<param><key>rangeType</key><value>int</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fir_LP</value></param>
<param><key>value</key><value> firdes.low_pass(1, samp_rate, 1000.0, 100.0, firdes.WIN_HAMMING, 6.76)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>80.1</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SQR_WAVE</value></param>
</block>
<block>
<key>block_custom_filter</key>
<param><key>id</key><value>block_custom_filter_0</value></param>
<param><key>algorithm_ID</key><value>algorithm_ID</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>fir_Taps</key><value>fir_LP</value></param>
<param><key>iir_feedback_Taps</key><value>IIR_feedback_0</value></param>
<param><key>iir_forward_Taps</key><value>IIR_feedforward_0</value></param>
<param><key>freq_min</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>freq_transition</key><value>100</value></param>
<param><key>freq_max</key><value>1000</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>iir_filter_xxx</key>
<param><key>id</key><value>iir_filter_xxx_0</value></param>
<param><key>fftaps</key><value>IIR_feedforward_1</value></param>
<param><key>fbtaps</key><value>IIR_feedback_1</value></param>
<param><key>oldstyle</key><value>False</value></param>
<param><key>type</key><value>ffd</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>1,0,1,2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>custom</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>raw</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>IIR</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>10000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymin</key><value>-2</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>block_custom_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>iir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>block_custom_filter_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>iir_filter_xxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
</flow_graph>
