<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>block_aggregation</value></param>
<param><key>author</key><value>rstein</value></param>
<param><key>category</key><value>[Custom Blocks]</value></param>
<param><key>description</key><value>computes low-pass filter and decimation including computiation/propagation of error estimates. Algorithm ID selects filter implementation (0: FIR-LP, 1: FIR-BP, 2: FIR-CUSTOM, 3: FIR-CUSTOM_FFT, 4: IIR_LP, 5: IIR_HP, 6: IIR-CUSTOM)</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>B.3 Data Aggregation</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation2</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>algorithm_ID</value></param>
<param><key>label</key><value>Algorithm ID</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>block_custom_filter</key>
<param><key>id</key><value>block_custom_filter_0</value></param>
<param><key>algorithm_ID</key><value>algorithm_ID</value></param>
<param><key>decimation</key><value>decimation2</value></param>
<param><key>fir_Taps</key><value>fir_Taps</value></param>
<param><key>iir_feedback_Taps</key><value>iir_feedback_Taps</value></param>
<param><key>iir_forward_Taps</key><value>iir_forward_Taps</value></param>
<param><key>freq_min</key><value>freq_min</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>freq_transition</key><value>freq_transition</value></param>
<param><key>freq_max</key><value>freq_max</value></param>
</block>
<block>
<key>block_custom_filter</key>
<param><key>id</key><value>block_custom_filter_0_0</value></param>
<param><key>algorithm_ID</key><value>algorithm_ID</value></param>
<param><key>decimation</key><value>decimation2</value></param>
<param><key>fir_Taps</key><value>fir_Taps</value></param>
<param><key>iir_feedback_Taps</key><value>iir_feedback_Taps</value></param>
<param><key>iir_forward_Taps</key><value>iir_forward_Taps</value></param>
<param><key>freq_min</key><value>freq_min</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>freq_transition</key><value>freq_transition</value></param>
<param><key>freq_max</key><value>freq_max</value></param>
</block>
<block>
<key>block_custom_filter</key>
<param><key>id</key><value>block_custom_filter_0_0_0</value></param>
<param><key>algorithm_ID</key><value>algorithm_ID</value></param>
<param><key>decimation</key><value>decimation2</value></param>
<param><key>fir_Taps</key><value>fir_Taps</value></param>
<param><key>iir_feedback_Taps</key><value>iir_feedback_Taps</value></param>
<param><key>iir_forward_Taps</key><value>iir_forward_Taps</value></param>
<param><key>freq_min</key><value>freq_min</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>freq_transition</key><value>freq_transition</value></param>
<param><key>freq_max</key><value>freq_max</value></param>
</block>
<block>
<key>block_custom_filter</key>
<param><key>id</key><value>block_custom_filter_0_0_0_0</value></param>
<param><key>algorithm_ID</key><value>algorithm_ID</value></param>
<param><key>decimation</key><value>decimation2</value></param>
<param><key>fir_Taps</key><value>fir_Taps</value></param>
<param><key>iir_feedback_Taps</key><value>iir_feedback_Taps</value></param>
<param><key>iir_forward_Taps</key><value>iir_forward_Taps</value></param>
<param><key>freq_min</key><value>freq_min</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>freq_transition</key><value>freq_transition</value></param>
<param><key>freq_max</key><value>freq_max</value></param>
</block>
<block>
<key>block_square</key>
<param><key>id</key><value>block_square_0</value></param>
</block>
<block>
<key>block_square</key>
<param><key>id</key><value>block_square_1</value></param>
</block>
<block>
<key>block_square</key>
<param><key>id</key><value>block_square_1_0</value></param>
</block>
<block>
<key>blocks_abs_xx</key>
<param><key>id</key><value>blocks_abs_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>delay</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0</value></param>
<param><key>n</key><value>decimation1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0_0</value></param>
<param><key>n</key><value>decimation1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0_1</value></param>
<param><key>n</key><value>decimation1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0_1_0</value></param>
<param><key>n</key><value>decimation1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>(freq_max-freq_min)/(1.0*samp_rate)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_transcendental</key>
<param><key>id</key><value>blocks_transcendental_0_0</value></param>
<param><key>name</key><value>sqrt</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decimation1</value></param>
<param><key>label</key><value>Decimation</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>delay</value></param>
<param><key>label</key><value>Delay of 'out' path</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fir_Taps</value></param>
<param><key>label</key><value>FIR Taps User</value></param>
<param><key>value</key><value>()</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_max</value></param>
<param><key>label</key><value>Upper Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_min</value></param>
<param><key>label</key><value>Lower Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_transition</value></param>
<param><key>label</key><value>Transition Width</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>iir_feedback_Taps</value></param>
<param><key>label</key><value>IIR Feedback Taps User</value></param>
<param><key>value</key><value>()</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>iir_forward_Taps</value></param>
<param><key>label</key><value>IIR Forward Taps User</value></param>
<param><key>value</key><value>()</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>sigma</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0</value></param>
<param><key>label</key><value>sigma_in</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<connection><source_block_id>block_custom_filter_0</source_block_id><sink_block_id>block_custom_filter_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>block_custom_filter_0</source_block_id><sink_block_id>block_square_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>block_custom_filter_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>block_custom_filter_0_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>block_custom_filter_0_0_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>block_custom_filter_0_0_0_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>block_square_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>block_square_1</source_block_id><sink_block_id>block_custom_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>block_square_1_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_abs_xx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_transcendental_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0_0</source_block_id><sink_block_id>block_square_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0_1</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0_1_0</source_block_id><sink_block_id>block_square_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>blocks_abs_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_transcendental_0_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>block_custom_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>block_custom_filter_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
