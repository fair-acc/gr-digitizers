<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>iq_down_converter</value></param>
<param><key>author</key><value>rstein</value></param>
<param><key>category</key><value>[digitizerRef]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>thread_safe_setters</key><value>1</value></param>
<param><key>title</key><value>B.5 IQ down-converter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TWO_PI</value></param>
<param><key>value</key><value>6.28318530718</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>algorithm_id</value></param>
<param><key>label</key><value>Algorithm ID</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>block_custom_filter</key>
<param><key>id</key><value>block_custom_filter_0</value></param>
<param><key>algorithm_ID</key><value>algorithm_id</value></param>
<param><key>decimation</key><value>decimation</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fir_Taps</key><value>fir_taps_user</value></param>
<param><key>iir_feedback_Taps</key><value>iir_feedback_Taps</value></param>
<param><key>iir_forward_Taps</key><value>iir_forward_Taps</value></param>
<param><key>freq_min</key><value>freq_min</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>freq_transition</key><value>freq_transition</value></param>
<param><key>freq_max</key><value>freq_max</value></param>
</block>
<block>
<key>block_custom_filter</key>
<param><key>id</key><value>block_custom_filter_0_0</value></param>
<param><key>algorithm_ID</key><value>algorithm_id</value></param>
<param><key>decimation</key><value>decimation</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fir_Taps</key><value>fir_taps_user</value></param>
<param><key>iir_feedback_Taps</key><value>iir_feedback_Taps</value></param>
<param><key>iir_forward_Taps</key><value>iir_forward_Taps</value></param>
<param><key>freq_min</key><value>freq_min</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>freq_transition</key><value>freq_transition</value></param>
<param><key>freq_max</key><value>freq_max</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0_0_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decimation</value></param>
<param><key>label</key><value>Decimation</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>digitizers_block_custom_filter</key>
<param><key>id</key><value>digitizers_block_custom_filter_0</value></param>
<param><key>alg_id</key><value>algorithm_id</value></param>
<param><key>decim</key><value>decimation</value></param>
<param><key>fir_taps</key><value>fir_taps_user</value></param>
<param><key>fb_user_taps</key><value>iir_feedback_Taps</value></param>
<param><key>fw_user_taps</key><value>iir_forward_Taps</value></param>
<param><key>low_freq</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>tr_width</key><value>freq_transition</value></param>
<param><key>up_freq</key><value>freq_max</value></param>
</block>
<block>
<key>digitizers_block_custom_filter</key>
<param><key>id</key><value>digitizers_block_custom_filter_0_0</value></param>
<param><key>alg_id</key><value>algorithm_id</value></param>
<param><key>decim</key><value>decimation</value></param>
<param><key>fir_taps</key><value>fir_taps_user</value></param>
<param><key>fb_user_taps</key><value>iir_feedback_Taps</value></param>
<param><key>fw_user_taps</key><value>iir_forward_Taps</value></param>
<param><key>low_freq</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>tr_width</key><value>freq_transition</value></param>
<param><key>up_freq</key><value>freq_max</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fir_taps_user</value></param>
<param><key>label</key><value>FIR Taps User</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_max</value></param>
<param><key>label</key><value>Upper Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_min</value></param>
<param><key>label</key><value>Lower Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_transition</value></param>
<param><key>label</key><value>Transition Width</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>hilbert_fc</key>
<param><key>id</key><value>hilbert_fc_1</value></param>
<param><key>num_taps</key><value>hilbert_taps</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>hilbert_fc</key>
<param><key>id</key><value>hilbert_fc_1_0</value></param>
<param><key>num_taps</key><value>hilbert_taps</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hilbert_taps</value></param>
<param><key>label</key><value>N Hilbert Filter Taps</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>iir_feedback_Taps</value></param>
<param><key>label</key><value>IIR Feedback Taps User</value></param>
<param><key>value</key><value>()</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>iir_forward_Taps</value></param>
<param><key>label</key><value>IIR Forward Taps User</value></param>
<param><key>value</key><value>()</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>freq_max</value></param>
<param><key>decim</key><value>decimation</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>0.1*freq_max</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>cutoff_freq</key><value>freq_max</value></param>
<param><key>decim</key><value>decimation</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>0.1*freq_max</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>ref</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<connection><source_block_id>block_custom_filter_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>block_custom_filter_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0_0</source_block_id><sink_block_id>block_custom_filter_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0_0</source_block_id><sink_block_id>digitizers_block_custom_filter_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0_0</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0_0</source_block_id><sink_block_id>block_custom_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0_0</source_block_id><sink_block_id>digitizers_block_custom_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>blocks_complex_to_float_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_block_custom_filter_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_block_custom_filter_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>hilbert_fc_1</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>hilbert_fc_1_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>hilbert_fc_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>hilbert_fc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
