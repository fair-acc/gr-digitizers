<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>b2_time_realignment_test</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimate</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>history</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pre_samples</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samples</value></param>
<param><key>value</key><value>9000</value></param>
</block>
<block>
<key>block_error_band</key>
<param><key>id</key><value>block_error_band_0</value></param>
</block>
<block>
<key>block_error_band</key>
<param><key>id</key><value>block_error_band_0_0</value></param>
</block>
<block>
<key>block_error_band</key>
<param><key>id</key><value>block_error_band_0_0_0</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>-0.5</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0_0</value></param>
<param><key>const</key><value>0.5</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0_1_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0_2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>digitizers_block_aggregation</key>
<param><key>id</key><value>digitizers_block_aggregation_0_1</value></param>
<param><key>alg_id</key><value>0</value></param>
<param><key>decim</key><value>decimate</value></param>
<param><key>delay</key><value>0</value></param>
<param><key>fir_taps</key><value>()</value></param>
<param><key>fb_user_taps</key><value>()</value></param>
<param><key>fw_user_taps</key><value>()</value></param>
<param><key>low_freq</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>tr_width</key><value>50000</value></param>
<param><key>up_freq</key><value>500000</value></param>
</block>
<block>
<key>digitizers_block_aggregation</key>
<param><key>id</key><value>digitizers_block_aggregation_0_1_0</value></param>
<param><key>alg_id</key><value>0</value></param>
<param><key>decim</key><value>decimate</value></param>
<param><key>delay</key><value>0</value></param>
<param><key>fir_taps</key><value>()</value></param>
<param><key>fb_user_taps</key><value>()</value></param>
<param><key>fw_user_taps</key><value>()</value></param>
<param><key>low_freq</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>tr_width</key><value>10000</value></param>
<param><key>up_freq</key><value>100000</value></param>
</block>
<block>
<key>digitizers_block_aggregation</key>
<param><key>id</key><value>digitizers_block_aggregation_0_1_0_0</value></param>
<param><key>alg_id</key><value>0</value></param>
<param><key>decim</key><value>decimate</value></param>
<param><key>delay</key><value>0</value></param>
<param><key>fir_taps</key><value>()</value></param>
<param><key>fb_user_taps</key><value>()</value></param>
<param><key>fw_user_taps</key><value>()</value></param>
<param><key>low_freq</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>tr_width</key><value>1000</value></param>
<param><key>up_freq</key><value>10000</value></param>
</block>
<block>
<key>digitizers_demux_ff</key>
<param><key>id</key><value>digitizers_demux_ff_0</value></param>
<param><key>history</key><value>history</value></param>
<param><key>post_trigger_window</key><value>samples/decimate</value></param>
<param><key>pre_trigger_window</key><value>pre_samples/decimate</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>digitizers_demux_ff</key>
<param><key>id</key><value>digitizers_demux_ff_0_0</value></param>
<param><key>history</key><value>history</value></param>
<param><key>post_trigger_window</key><value>samples/decimate</value></param>
<param><key>pre_trigger_window</key><value>pre_samples/decimate</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>digitizers_demux_ff</key>
<param><key>id</key><value>digitizers_demux_ff_0_0_0</value></param>
<param><key>history</key><value>history</value></param>
<param><key>post_trigger_window</key><value>samples/decimate</value></param>
<param><key>pre_trigger_window</key><value>pre_samples/decimate</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>digitizers_picoscope_3000a</key>
<param><key>id</key><value>digitizers_picoscope_3000a_0</value></param>
<param><key>acquisition_mode</key><value>Streaming</value></param>
<param><key>buff_size</key><value>500000</value></param>
<param><key>enable_ai_a</key><value>True</value></param>
<param><key>enable_ai_b</key><value>False</value></param>
<param><key>enable_ai_c</key><value>False</value></param>
<param><key>enable_ai_d</key><value>False</value></param>
<param><key>coupling_ai_a</key><value>True</value></param>
<param><key>coupling_ai_b</key><value>True</value></param>
<param><key>coupling_ai_c</key><value>False</value></param>
<param><key>coupling_ai_d</key><value>False</value></param>
<param><key>downsampling_factor</key><value>16</value></param>
<param><key>downsampling_mode</key><value>0</value></param>
<param><key>nr_waveforms</key><value>2</value></param>
<param><key>nr_buffers</key><value>100</value></param>
<param><key>driver_buff_size</key><value>100000</value></param>
<param><key>pin_number</key><value>0</value></param>
<param><key>poll_rate</key><value>0.0005</value></param>
<param><key>thresh_di_0</key><value>2.5</value></param>
<param><key>enable_di_0</key><value>False</value></param>
<param><key>thresh_di_1</key><value>2.5</value></param>
<param><key>enable_di_1</key><value>False</value></param>
<param><key>samples</key><value>samples*2</value></param>
<param><key>pre_samples</key><value>pre_samples*2</value></param>
<param><key>range_ai_a</key><value>1</value></param>
<param><key>range_ai_b</key><value>5</value></param>
<param><key>range_ai_c</key><value>5</value></param>
<param><key>range_ai_d</key><value>5.0</value></param>
<param><key>offset_ai_a</key><value>0.0</value></param>
<param><key>offset_ai_b</key><value>0.0</value></param>
<param><key>offset_ai_c</key><value>5.0</value></param>
<param><key>offset_ai_d</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>serial_number</key><value></value></param>
<param><key>trigger_direction</key><value>0</value></param>
<param><key>trigger_once</key><value>False</value></param>
<param><key>trigger_source</key><value>A</value></param>
<param><key>trigger_threshold</key><value>0.95</value></param>
</block>
<block>
<key>digitizers_time_realignment_ff</key>
<param><key>id</key><value>digitizers_time_realignment_ff_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>user_delay</key><value>0.0</value></param>
</block>
<block>
<key>digitizers_time_realignment_ff</key>
<param><key>id</key><value>digitizers_time_realignment_ff_0_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>user_delay</key><value>0.00</value></param>
</block>
<block>
<key>digitizers_time_realignment_ff</key>
<param><key>id</key><value>digitizers_time_realignment_ff_0_0_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>user_delay</key><value>-0.00</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>-</value></param>
<param><key>style1</key><value>2</value></param>
<param><key>color2</key><value>"blue"</value></param>
<param><key>label2</key><value>baseline 500 kHz LP</value></param>
<param><key>color3</key><value>"blue"</value></param>
<param><key>label3</key><value>-</value></param>
<param><key>style3</key><value>2</value></param>
<param><key>color4</key><value>"red"</value></param>
<param><key>label4</key><value>-</value></param>
<param><key>style4</key><value>2</value></param>
<param><key>color5</key><value>"red"</value></param>
<param><key>label5</key><value>baseline 100 kHz LP</value></param>
<param><key>style5</key><value>0</value></param>
<param><key>color6</key><value>"red"</value></param>
<param><key>label6</key><value>-</value></param>
<param><key>style6</key><value>2</value></param>
<param><key>color7</key><value>"green"</value></param>
<param><key>label7</key><value>-</value></param>
<param><key>style7</key><value>2</value></param>
<param><key>color8</key><value>"green"</value></param>
<param><key>label8</key><value>baseline 10 kHz LP</value></param>
<param><key>color9</key><value>"green"</value></param>
<param><key>label9</key><value>-</value></param>
<param><key>style9</key><value>2</value></param>
<param><key>name</key><value>"Signals"</value></param>
<param><key>nconnections</key><value>9</value></param>
<param><key>size</key><value>(pre_samples+samples)/decimate</value></param>
<param><key>srate</key><value>samp_rate/decimate</value></param>
<param><key>tr_tag</key><value>"acq_info"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>V</value></param>
<param><key>ymax</key><value>2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>baseline 500 kHz LP</value></param>
<param><key>style1</key><value>0</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>baseline 100 kHz LP</value></param>
<param><key>style2</key><value>0</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>baseline 10 kHz LP</value></param>
<param><key>style3</key><value>0</value></param>
<param><key>name</key><value>"Tags"</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>(pre_samples+samples)/decimate</value></param>
<param><key>srate</key><value>samp_rate/decimate</value></param>
<param><key>tr_delay</key><value>0.005</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"acq_info"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>V</value></param>
</block>
<connection><source_block_id>block_error_band_0</source_block_id><sink_block_id>blocks_tag_gate_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>block_error_band_0</source_block_id><sink_block_id>blocks_tag_gate_0_1_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>block_error_band_0</source_block_id><sink_block_id>blocks_tag_gate_0_1_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>block_error_band_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>block_error_band_0_0</source_block_id><sink_block_id>blocks_tag_gate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>block_error_band_0_0</source_block_id><sink_block_id>blocks_tag_gate_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>block_error_band_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>block_error_band_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>block_error_band_0_0_0</source_block_id><sink_block_id>blocks_tag_gate_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>block_error_band_0_0_0</source_block_id><sink_block_id>blocks_tag_gate_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>block_error_band_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>block_error_band_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>block_error_band_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0_0</source_block_id><sink_block_id>block_error_band_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0_1_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0_2</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>digitizers_block_aggregation_0_1</source_block_id><sink_block_id>digitizers_demux_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_block_aggregation_0_1</source_block_id><sink_block_id>digitizers_demux_ff_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_block_aggregation_0_1_0</source_block_id><sink_block_id>digitizers_demux_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_block_aggregation_0_1_0</source_block_id><sink_block_id>digitizers_demux_ff_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_block_aggregation_0_1_0_0</source_block_id><sink_block_id>digitizers_demux_ff_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_block_aggregation_0_1_0_0</source_block_id><sink_block_id>digitizers_demux_ff_0_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_demux_ff_0</source_block_id><sink_block_id>block_error_band_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_demux_ff_0</source_block_id><sink_block_id>block_error_band_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_demux_ff_0_0</source_block_id><sink_block_id>block_error_band_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_demux_ff_0_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_demux_ff_0_0_0</source_block_id><sink_block_id>block_error_band_0_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_demux_ff_0_0_0</source_block_id><sink_block_id>blocks_add_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>digitizers_time_realignment_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>digitizers_time_realignment_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>digitizers_time_realignment_ff_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>digitizers_time_realignment_ff_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>digitizers_time_realignment_ff_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>digitizers_time_realignment_ff_0_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_time_realignment_ff_0</source_block_id><sink_block_id>digitizers_block_aggregation_0_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_time_realignment_ff_0</source_block_id><sink_block_id>digitizers_block_aggregation_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_time_realignment_ff_0_0</source_block_id><sink_block_id>digitizers_block_aggregation_0_1_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_time_realignment_ff_0_0</source_block_id><sink_block_id>digitizers_block_aggregation_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_time_realignment_ff_0_0_0</source_block_id><sink_block_id>digitizers_block_aggregation_0_1_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_time_realignment_ff_0_0_0</source_block_id><sink_block_id>digitizers_block_aggregation_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
