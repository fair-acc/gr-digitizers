<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>frequency_tracker</value></param>
<param><key>description</key><value>algorithm id:  0: FIR-LP, 1: FIR-BP, 2: FIR-CUSTOM, 3: FIR-CUSTOM_FFT, 4: IIR_LP, 5: IIR_HP, 6: IIR-CUSTOM</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>B4 RF-Amplitude, Phase and Frequency Detection (with digitizer)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pre_samples</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>20000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samples</value></param>
<param><key>value</key><value>900</value></param>
</block>
<block>
<key>ampl_phase_detector</key>
<param><key>id</key><value>ampl_phase_detector_0</value></param>
<param><key>algorithm_id</key><value>4</value></param>
<param><key>decimation</key><value>decimation</value></param>
<param><key>fir_taps_user</key><value>()</value></param>
<param><key>iir_feedback_Taps</key><value>()</value></param>
<param><key>iir_forward_Taps</key><value>()</value></param>
<param><key>freq_min</key><value>0</value></param>
<param><key>hilbert_taps</key><value>32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>freq_transition</key><value>100</value></param>
<param><key>freq_max</key><value>100</value></param>
</block>
<block>
<key>block_error_band</key>
<param><key>id</key><value>block_error_band_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>n</key><value>decimation</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>4</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>4</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate/decimation</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>digitizers_block_amplitude_and_phase</key>
<param><key>id</key><value>digitizers_block_amplitude_and_phase_0</value></param>
<param><key>cutoff</key><value>100</value></param>
<param><key>decim</key><value>decimation</value></param>
<param><key>delay</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>hil_win</key><value>32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>tr_width</key><value>100</value></param>
</block>
<block>
<key>digitizers_block_complex_to_mag_deg</key>
<param><key>id</key><value>digitizers_block_complex_to_mag_deg_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>vec_size</key><value>1</value></param>
</block>
<block>
<key>digitizers_picoscope_3000a</key>
<param><key>id</key><value>digitizers_picoscope_3000a_0</value></param>
<param><key>acquisition_mode</key><value>Streaming</value></param>
<param><key>enable_ai_a</key><value>True</value></param>
<param><key>enable_ai_b</key><value>False</value></param>
<param><key>enable_ai_c</key><value>True</value></param>
<param><key>enable_ai_d</key><value>False</value></param>
<param><key>affinity</key><value>1</value></param>
<param><key>coupling_ai_a</key><value>True</value></param>
<param><key>coupling_ai_b</key><value>True</value></param>
<param><key>coupling_ai_c</key><value>True</value></param>
<param><key>coupling_ai_d</key><value>False</value></param>
<param><key>downsampling_factor</key><value>4</value></param>
<param><key>downsampling_mode</key><value>0</value></param>
<param><key>buff_size</key><value>16000</value></param>
<param><key>maxoutbuf</key><value>1000000</value></param>
<param><key>minoutbuf</key><value>10000</value></param>
<param><key>nr_waveforms</key><value>1</value></param>
<param><key>pin_number</key><value>0</value></param>
<param><key>poll_rate</key><value>0.005</value></param>
<param><key>thresh_di_0</key><value>1.5</value></param>
<param><key>enable_di_0</key><value>True</value></param>
<param><key>thresh_di_1</key><value>1.5</value></param>
<param><key>enable_di_1</key><value>False</value></param>
<param><key>samples</key><value>samples</value></param>
<param><key>pre_samples</key><value>pre_samples</value></param>
<param><key>range_ai_a</key><value>2</value></param>
<param><key>range_ai_b</key><value>5</value></param>
<param><key>range_ai_c</key><value>5</value></param>
<param><key>range_ai_d</key><value>0.1</value></param>
<param><key>offset_ai_a</key><value>0</value></param>
<param><key>offset_ai_b</key><value>0.0</value></param>
<param><key>offset_ai_c</key><value>0.0</value></param>
<param><key>offset_ai_d</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>serial_number</key><value>FP635/012</value></param>
<param><key>trigger_direction</key><value>0</value></param>
<param><key>trigger_once</key><value>False</value></param>
<param><key>trigger_source</key><value>None</value></param>
<param><key>trigger_threshold</key><value>0.5</value></param>
</block>
<block>
<key>frequencyCounter_frequency_counter_ff</key>
<param><key>id</key><value>frequencyCounter_frequency_counter_ff_0</value></param>
<param><key>hi</key><value>+0.1</value></param>
<param><key>lo</key><value>-0.1</value></param>
<param><key>ncycles</key><value>10</value></param>
<param><key>sampling</key><value>samp_rate</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>2,1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>freqhalf</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.1</value></param>
<param><key>wintype</key><value>firdes.WIN_HANN</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>2,0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>A</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>B</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>C</value></param>
<param><key>color4</key><value>"yellow"</value></param>
<param><key>label4</key><value>D</value></param>
<param><key>name</key><value>"Analog"</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>size</key><value>samples + pre_samples</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>acq_info</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.1</value></param>
<param><key>yunit</key><value>"V"</value></param>
<param><key>ymax</key><value>+1.1</value></param>
<param><key>ymin</key><value>-1.1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>P0</value></param>
<param><key>color2</key><value>"black"</value></param>
<param><key>label2</key><value>P1</value></param>
<param><key>name</key><value>"Digital"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>samples + pre_samples</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>Decimal nr.</value></param>
<param><key>ymax</key><value>5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>max</value></param>
<param><key>style1</key><value>2</value></param>
<param><key>color2</key><value>"blue"</value></param>
<param><key>label2</key><value>mean</value></param>
<param><key>color3</key><value>"blue"</value></param>
<param><key>label3</key><value>min</value></param>
<param><key>style3</key><value>2</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>samples + pre_samples</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_tag</key><value>acq_info</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>Amplitude Channel C</value></param>
<param><key>ymax</key><value>0.02</value></param>
<param><key>ymin</key><value>-0.02</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>gui_hint</key><value>0,0,1,2</value></param>
<param><key>color1</key><value>"green"</value></param>
<param><key>label1</key><value>Freq</value></param>
<param><key>size</key><value>1000</value></param>
<param><key>srate</key><value>samp_rate/decimation</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.1</value></param>
<param><key>ylabel</key><value>Frequency</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>mag</value></param>
<param><key>size</key><value>1000</value></param>
<param><key>srate</key><value>samp_rate/decimation</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>gui_hint</key><value>1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>label1</key><value>phase</value></param>
<param><key>size</key><value>1000</value></param>
<param><key>srate</key><value>samp_rate/decimation</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.1</value></param>
<param><key>ylabel</key><value>Phase [deg]</value></param>
</block>
<connection><source_block_id>ampl_phase_detector_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ampl_phase_detector_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>block_error_band_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>block_error_band_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>block_error_band_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_time_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_block_amplitude_and_phase_0</source_block_id><sink_block_id>digitizers_block_complex_to_mag_deg_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>ampl_phase_detector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>digitizers_block_amplitude_and_phase_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>ampl_phase_detector_0</sink_block_id><source_key>4</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>block_error_band_0</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>4</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>digitizers_block_amplitude_and_phase_0</sink_block_id><source_key>4</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>frequencyCounter_frequency_counter_ff_0</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>6</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>6</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>3</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>block_error_band_0</sink_block_id><source_key>5</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>5</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>7</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>blocks_uchar_to_float_0</sink_block_id><source_key>8</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>frequencyCounter_frequency_counter_ff_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
