<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ps4000a_streaming_test</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>20000000</value></param>
</block>
<block>
<key>block_error_band</key>
<param><key>id</key><value>block_error_band_0</value></param>
</block>
<block>
<key>block_error_band</key>
<param><key>id</key><value>block_error_band_0_0</value></param>
</block>
<block>
<key>block_error_band</key>
<param><key>id</key><value>block_error_band_0_0_0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>8</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>8</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digitizers_picoscope_4000a</key>
<param><key>id</key><value>digitizers_picoscope_4000a_0</value></param>
<param><key>acquisition_mode</key><value>Streaming</value></param>
<param><key>enable_ai_a</key><value>True</value></param>
<param><key>enable_ai_b</key><value>True</value></param>
<param><key>enable_ai_c</key><value>True</value></param>
<param><key>enable_ai_d</key><value>True</value></param>
<param><key>enable_ai_e</key><value>True</value></param>
<param><key>enable_ai_f</key><value>True</value></param>
<param><key>enable_ai_g</key><value>True</value></param>
<param><key>enable_ai_h</key><value>True</value></param>
<param><key>coupling_ai_a</key><value>True</value></param>
<param><key>coupling_ai_b</key><value>True</value></param>
<param><key>coupling_ai_c</key><value>True</value></param>
<param><key>coupling_ai_d</key><value>True</value></param>
<param><key>coupling_ai_e</key><value>True</value></param>
<param><key>coupling_ai_f</key><value>True</value></param>
<param><key>coupling_ai_g</key><value>True</value></param>
<param><key>coupling_ai_h</key><value>True</value></param>
<param><key>downsampling_factor</key><value>20</value></param>
<param><key>downsampling_mode</key><value>0</value></param>
<param><key>buff_size</key><value>10000</value></param>
<param><key>nr_waveforms</key><value>5</value></param>
<param><key>poll_rate</key><value>0.001</value></param>
<param><key>samples</key><value>10000</value></param>
<param><key>pre_samples</key><value>0</value></param>
<param><key>range_ai_a</key><value>1</value></param>
<param><key>range_ai_b</key><value>1</value></param>
<param><key>range_ai_c</key><value>1</value></param>
<param><key>range_ai_d</key><value>1</value></param>
<param><key>range_ai_e</key><value>1</value></param>
<param><key>range_ai_f</key><value>1</value></param>
<param><key>range_ai_g</key><value>1</value></param>
<param><key>range_ai_h</key><value>1</value></param>
<param><key>offset_ai_a</key><value>0</value></param>
<param><key>offset_ai_b</key><value>0.0</value></param>
<param><key>offset_ai_c</key><value>0</value></param>
<param><key>offset_ai_d</key><value>0.0</value></param>
<param><key>offset_ai_e</key><value>0.0</value></param>
<param><key>offset_ai_f</key><value>0.0</value></param>
<param><key>offset_ai_g</key><value>0.0</value></param>
<param><key>offset_ai_h</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>serial_number</key><value>EW413/194</value></param>
<param><key>trigger_direction</key><value>0</value></param>
<param><key>trigger_once</key><value>False</value></param>
<param><key>trigger_source</key><value>None</value></param>
<param><key>trigger_threshold</key><value>0</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>label2</key><value></value></param>
<param><key>label3</key><value></value></param>
<param><key>label4</key><value></value></param>
<param><key>label5</key><value></value></param>
<param><key>label6</key><value></value></param>
<param><key>label7</key><value></value></param>
<param><key>label8</key><value></value></param>
<param><key>nconnections</key><value>8</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>freqhalf</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.5</value></param>
<param><key>wintype</key><value>firdes.WIN_HANN</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>-</value></param>
<param><key>style1</key><value>2</value></param>
<param><key>color2</key><value>"blue"</value></param>
<param><key>label2</key><value>channel A</value></param>
<param><key>color3</key><value>"blue"</value></param>
<param><key>label3</key><value>-</value></param>
<param><key>style3</key><value>2</value></param>
<param><key>color4</key><value>"red"</value></param>
<param><key>label4</key><value>-</value></param>
<param><key>style4</key><value>2</value></param>
<param><key>color5</key><value>"red"</value></param>
<param><key>label5</key><value>channel B</value></param>
<param><key>color6</key><value>"red"</value></param>
<param><key>label6</key><value>-</value></param>
<param><key>style6</key><value>2</value></param>
<param><key>color7</key><value>"green"</value></param>
<param><key>label7</key><value>-</value></param>
<param><key>style7</key><value>2</value></param>
<param><key>color8</key><value>"green"</value></param>
<param><key>label8</key><value>channel C</value></param>
<param><key>color9</key><value>"green"</value></param>
<param><key>label9</key><value>-</value></param>
<param><key>style9</key><value>2</value></param>
<param><key>nconnections</key><value>9</value></param>
<param><key>size</key><value>4096</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_level</key><value>0.1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.5</value></param>
<param><key>ymax</key><value>5</value></param>
<param><key>ymin</key><value>-5</value></param>
</block>
<connection><source_block_id>block_error_band_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>block_error_band_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>block_error_band_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>block_error_band_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>block_error_band_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>block_error_band_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>block_error_band_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>block_error_band_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>block_error_band_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>block_error_band_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>block_error_band_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>block_error_band_0_0_0</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>4</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>4</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>6</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>6</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>8</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>8</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>10</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>10</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>12</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>12</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>14</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>14</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>block_error_band_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>block_error_band_0_0</sink_block_id><source_key>3</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>3</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>block_error_band_0_0_0</sink_block_id><source_key>5</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>5</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>7</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>9</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>11</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>13</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>15</source_key><sink_key>0</sink_key></connection>
</flow_graph>
