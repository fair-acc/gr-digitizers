<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>user_delay_test</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ch_a_f</value></param>
<param><key>value</key><value>15000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ch_b_f</value></param>
<param><key>value</key><value>50000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>user_delay</value></param>
<param><key>value</key><value>0.0001</value></param>
<param><key>label</key><value>User Delay (s)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-0.0005</value></param>
<param><key>step</key><value>0.00005</value></param>
<param><key>stop</key><value>0.0005</value></param>
</block>
<block>
<key>variable_tag_object</key>
<param><key>id</key><value>wr_tag</value></param>
<param><key>key</key><value>pmt.intern("wr_event")</value></param>
<param><key>offset</key><value>4100</value></param>
<param><key>src</key><value>pmt.intern("src")</value></param>
<param><key>value</key><value>pmt.make_tuple(pmt.string_to_symbol('foo'), pmt.from_uint64(2000000000), pmt.from_uint64(1900000000), pmt.from_bool(False), pmt.from_bool(False))</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>0.04</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>float</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>4</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>After Demux</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>Tags Before</value></param>
</block>
<block>
<key>blocks_tag_share</key>
<param><key>id</key><value>blocks_tag_share_0</value></param>
<param><key>io_type</key><value>float</value></param>
<param><key>share_type</key><value>float</value></param>
</block>
<block>
<key>blocks_tag_share</key>
<param><key>id</key><value>blocks_tag_share_0_0_0_0</value></param>
<param><key>io_type</key><value>float</value></param>
<param><key>share_type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>tags</key><value>[wr_tag]</value></param>
<param><key>vector</key><value>([0] *8192) </value></param>
</block>
<block>
<key>digitizers_block_demux</key>
<param><key>id</key><value>digitizers_block_demux_0</value></param>
<param><key>bit_to_keep</key><value>0</value></param>
</block>
<block>
<key>digitizers_demux_ff</key>
<param><key>id</key><value>digitizers_demux_ff_0</value></param>
<param><key>history</key><value>100000</value></param>
<param><key>post_trigger_window</key><value>1000</value></param>
<param><key>pre_trigger_window</key><value>500</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>digitizers_demux_ff</key>
<param><key>id</key><value>digitizers_demux_ff_0_0</value></param>
<param><key>history</key><value>100000</value></param>
<param><key>post_trigger_window</key><value>1000</value></param>
<param><key>pre_trigger_window</key><value>500</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>digitizers_demux_ff</key>
<param><key>id</key><value>digitizers_demux_ff_0_0_0</value></param>
<param><key>history</key><value>100000</value></param>
<param><key>post_trigger_window</key><value>1000</value></param>
<param><key>pre_trigger_window</key><value>500</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>digitizers_demux_ff</key>
<param><key>id</key><value>digitizers_demux_ff_0_1</value></param>
<param><key>history</key><value>100000</value></param>
<param><key>post_trigger_window</key><value>1000</value></param>
<param><key>pre_trigger_window</key><value>500</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>digitizers_simulation_source</key>
<param><key>id</key><value>digitizers_simulation_source_0</value></param>
<param><key>acquisition_mode</key><value>Streaming</value></param>
<param><key>buff_size</key><value>8192</value></param>
<param><key>ch_a_data</key><value>numpy.sin(2 * numpy.pi * numpy.arange(8192) * ch_a_f/samp_rate).astype(numpy.float32).tolist()</value></param>
<param><key>ch_b_data</key><value>numpy.cos(2 * numpy.pi * numpy.arange(8192) * ch_b_f/samp_rate).astype(numpy.float32).tolist()</value></param>
<param><key>pin_number</key><value>0</value></param>
<param><key>poll_rate</key><value>0.0005</value></param>
<param><key>port_data</key><value>([0] *4000) + ([1] *192) + ([0] *4000)</value></param>
<param><key>samples</key><value>4192</value></param>
<param><key>pre_samples</key><value>4000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>trigger_direction</key><value>0</value></param>
<param><key>trigger_once</key><value>False</value></param>
<param><key>trigger_source</key><value>Digital</value></param>
<param><key>trigger_threshold</key><value>0.9</value></param>
</block>
<block>
<key>digitizers_time_realignment_ff</key>
<param><key>id</key><value>digitizers_time_realignment_ff_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>user_delay</key><value>0.0</value></param>
</block>
<block>
<key>digitizers_time_realignment_ff</key>
<param><key>id</key><value>digitizers_time_realignment_ff_0_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>user_delay</key><value>user_delay</value></param>
</block>
<block>
<key>digitizers_time_realignment_ff</key>
<param><key>id</key><value>digitizers_time_realignment_ff_0_0_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>user_delay</key><value>0.0</value></param>
</block>
<block>
<key>digitizers_time_realignment_ff</key>
<param><key>id</key><value>digitizers_time_realignment_ff_0_0_0_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>user_delay</key><value>user_delay</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>0,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>D0</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>D0 + Delay</value></param>
<param><key>name</key><value>"Digital"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1500</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.5</value></param>
<param><key>ylabel</key><value>Digital Nr</value></param>
<param><key>ymax</key><value>5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>A</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>A + Delay</value></param>
<param><key>name</key><value>Analog</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1500</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_level</key><value>0.5</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>V</value></param>
<param><key>ymax</key><value>5</value></param>
<param><key>ymin</key><value>-5</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_tag_share_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_share_0</source_block_id><sink_block_id>digitizers_time_realignment_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_share_0</source_block_id><sink_block_id>digitizers_time_realignment_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_share_0_0_0_0</source_block_id><sink_block_id>digitizers_time_realignment_ff_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_share_0_0_0_0</source_block_id><sink_block_id>digitizers_time_realignment_ff_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>blocks_tag_share_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_tag_share_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_block_demux_0</source_block_id><sink_block_id>blocks_tag_share_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_demux_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_demux_ff_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_demux_ff_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_demux_ff_0_1</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_demux_ff_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_simulation_source_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_simulation_source_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>digitizers_simulation_source_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_simulation_source_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_simulation_source_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>3</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>digitizers_simulation_source_0</source_block_id><sink_block_id>digitizers_block_demux_0</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_time_realignment_ff_0</source_block_id><sink_block_id>digitizers_demux_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_time_realignment_ff_0_0</source_block_id><sink_block_id>blocks_tag_debug_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_time_realignment_ff_0_0</source_block_id><sink_block_id>digitizers_demux_ff_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_time_realignment_ff_0_0_0</source_block_id><sink_block_id>digitizers_demux_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_time_realignment_ff_0_0_0_0</source_block_id><sink_block_id>digitizers_demux_ff_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
