<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>160000</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_tags_strobe</key>
<param><key>id</key><value>blocks_tags_strobe_0</value></param>
<param><key>key</key><value>pmt.intern("acq_info")</value></param>
<param><key>nsamps</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>value</key><value>pmt.make_tuple(pmt.from_uint64(10000), pmt.from_double(1.0/samp_rate), pmt.from_double(0.0), pmt.from_double(0.0), pmt.from_long(0), pmt.from_long(0), pmt.from_long(0), pmt.from_uint64(0), pmt.from_uint64(5000), pmt.from_bool(True))</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digitizers_function_ff</key>
<param><key>id</key><value>digitizers_function_ff_0</value></param>
<param><key>decimation</key><value>4</value></param>
<param><key>max</key><value>(1.2, 1.4, 1.65, 1.2)</value></param>
<param><key>min</key><value>(0.8, 1.0, 1.25, 0.8)</value></param>
<param><key>reference</key><value>(1.0, 1.2, 1.45, 1.0)</value></param>
<param><key>time</key><value>(0.1, 0.5, 0.7, 0.9)</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Ref</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Min</value></param>
<param><key>style2</key><value>3</value></param>
<param><key>color3</key><value>"red"</value></param>
<param><key>label3</key><value>Max</value></param>
<param><key>style3</key><value>4</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>samp_rate * 2</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.001</value></param>
<param><key>ymax</key><value>5</value></param>
<param><key>ymin</key><value>-2</value></param>
</block>
<connection><source_block_id>blocks_tags_strobe_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>digitizers_function_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_function_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>digitizers_function_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_function_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
