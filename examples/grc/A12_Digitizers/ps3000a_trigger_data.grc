<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pre_samples</value></param>
<param><key>value</key><value>5000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samples</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>4</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_0</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_0_0</value></param>
</block>
<block>
<key>digitizers_extractor</key>
<param><key>id</key><value>digitizers_extractor_a</value></param>
<param><key>drop_nontrigger_data</key><value>True</value></param>
<param><key>post_trigger_window</key><value>0.20</value></param>
<param><key>pre_trigger_window</key><value>0.05</value></param>
<param><key>timing_available</key><value>False</value></param>
<param><key>user_delay</key><value>0.0</value></param>
</block>
<block>
<key>digitizers_extractor</key>
<param><key>id</key><value>digitizers_extractor_b</value></param>
<param><key>drop_nontrigger_data</key><value>True</value></param>
<param><key>post_trigger_window</key><value>0.20</value></param>
<param><key>pre_trigger_window</key><value>0.05</value></param>
<param><key>timing_available</key><value>False</value></param>
<param><key>user_delay</key><value>0</value></param>
</block>
<block>
<key>digitizers_extractor</key>
<param><key>id</key><value>digitizers_extractor_c</value></param>
<param><key>drop_nontrigger_data</key><value>True</value></param>
<param><key>post_trigger_window</key><value>0.20</value></param>
<param><key>pre_trigger_window</key><value>0.05</value></param>
<param><key>timing_available</key><value>False</value></param>
<param><key>user_delay</key><value>0</value></param>
</block>
<block>
<key>digitizers_extractor</key>
<param><key>id</key><value>digitizers_extractor_d</value></param>
<param><key>drop_nontrigger_data</key><value>True</value></param>
<param><key>post_trigger_window</key><value>0.20</value></param>
<param><key>pre_trigger_window</key><value>0.05</value></param>
<param><key>timing_available</key><value>False</value></param>
<param><key>user_delay</key><value>0</value></param>
</block>
<block>
<key>digitizers_extractor</key>
<param><key>id</key><value>digitizers_extractor_p</value></param>
<param><key>drop_nontrigger_data</key><value>True</value></param>
<param><key>post_trigger_window</key><value>0.20</value></param>
<param><key>pre_trigger_window</key><value>0.05</value></param>
<param><key>timing_available</key><value>False</value></param>
<param><key>user_delay</key><value>0</value></param>
</block>
<block>
<key>digitizers_picoscope_3000a</key>
<param><key>id</key><value>digitizers_picoscope_3000a_0</value></param>
<param><key>acquisition_mode</key><value>Streaming</value></param>
<param><key>enable_ai_a</key><value>True</value></param>
<param><key>enable_ai_b</key><value>True</value></param>
<param><key>enable_ai_c</key><value>True</value></param>
<param><key>enable_ai_d</key><value>True</value></param>
<param><key>coupling_ai_a</key><value>True</value></param>
<param><key>coupling_ai_b</key><value>True</value></param>
<param><key>coupling_ai_c</key><value>True</value></param>
<param><key>coupling_ai_d</key><value>True</value></param>
<param><key>downsampling_factor</key><value>10</value></param>
<param><key>downsampling_mode</key><value>0</value></param>
<param><key>buff_size</key><value>900000</value></param>
<param><key>nr_waveforms</key><value>5</value></param>
<param><key>pin_number</key><value>0</value></param>
<param><key>poll_rate</key><value>0.005</value></param>
<param><key>thresh_di_0</key><value>1.5</value></param>
<param><key>enable_di_0</key><value>True</value></param>
<param><key>thresh_di_1</key><value>1.5</value></param>
<param><key>enable_di_1</key><value>True</value></param>
<param><key>samples</key><value>samples</value></param>
<param><key>pre_samples</key><value>pre_samples</value></param>
<param><key>range_ai_a</key><value>2</value></param>
<param><key>range_ai_b</key><value>5</value></param>
<param><key>range_ai_c</key><value>5</value></param>
<param><key>range_ai_d</key><value>10</value></param>
<param><key>offset_ai_a</key><value>0</value></param>
<param><key>offset_ai_b</key><value>0.0</value></param>
<param><key>offset_ai_c</key><value>0.0</value></param>
<param><key>offset_ai_d</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>serial_number</key><value></value></param>
<param><key>trigger_direction</key><value>0</value></param>
<param><key>trigger_once</key><value>False</value></param>
<param><key>trigger_source</key><value>A</value></param>
<param><key>trigger_threshold</key><value>1.0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>A</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>B</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>C</value></param>
<param><key>color4</key><value>"yellow"</value></param>
<param><key>label4</key><value>D</value></param>
<param><key>name</key><value>"Analog"</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>size</key><value>samples + pre_samples</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>yunit</key><value>"V"</value></param>
<param><key>ymax</key><value>5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>P0</value></param>
<param><key>color2</key><value>"black"</value></param>
<param><key>label2</key><value>P1</value></param>
<param><key>name</key><value>"Digital"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>samples + pre_samples</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>Decimal nr.</value></param>
<param><key>ymax</key><value>5</value></param>
</block>
<connection><source_block_id>blocks_uchar_to_float_0</source_block_id><sink_block_id>digitizers_extractor_p</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_0_0</source_block_id><sink_block_id>digitizers_extractor_p</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_extractor_a</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_extractor_a</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_extractor_b</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_extractor_b</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_extractor_c</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>digitizers_extractor_c</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>digitizers_extractor_d</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>digitizers_extractor_d</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>digitizers_extractor_p</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_extractor_p</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>digitizers_extractor_a</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>digitizers_extractor_b</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>digitizers_extractor_c</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>digitizers_extractor_d</sink_block_id><source_key>6</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>digitizers_extractor_a</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>digitizers_extractor_b</sink_block_id><source_key>3</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>digitizers_extractor_c</sink_block_id><source_key>5</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>digitizers_extractor_d</sink_block_id><source_key>7</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>blocks_uchar_to_float_0</sink_block_id><source_key>8</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>blocks_uchar_to_float_0_0</sink_block_id><source_key>9</source_key><sink_key>0</sink_key></connection>
</flow_graph>
