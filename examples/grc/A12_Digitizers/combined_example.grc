<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_max</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_max_0</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_transition</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>320000</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>7</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>digitizers_block_aggregation</key>
<param><key>id</key><value>digitizers_block_aggregation_0</value></param>
<param><key>alg_id</key><value>5</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>delay</key><value>0</value></param>
<param><key>fir_taps</key><value>firdes.low_pass(1, samp_rate, freq_max, freq_transition, firdes.WIN_HAMMING, 6.76)</value></param>
<param><key>fb_user_taps</key><value>firdes.low_pass(1, samp_rate, freq_max, freq_transition, firdes.WIN_HAMMING, 6.76)</value></param>
<param><key>fw_user_taps</key><value>firdes.low_pass(1, samp_rate, freq_max, freq_transition, firdes.WIN_HAMMING, 6.76)</value></param>
<param><key>low_freq</key><value>1000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>tr_width</key><value>50</value></param>
<param><key>up_freq</key><value>10000</value></param>
</block>
<block>
<key>digitizers_block_demux</key>
<param><key>id</key><value>digitizers_block_demux_0</value></param>
<param><key>bit_to_keep</key><value>5</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>digitizers_block_spectral_peaks</key>
<param><key>id</key><value>digitizers_block_spectral_peaks_0</value></param>
<param><key>avg_n</key><value>10</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_win</key><value>2048</value></param>
<param><key>lo_fq</key><value>80000</value></param>
<param><key>med_n</key><value>10</value></param>
<param><key>prox_n</key><value>10</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hi_fq</key><value>1000000</value></param>
</block>
<block>
<key>digitizers_freq_estimator</key>
<param><key>id</key><value>digitizers_freq_estimator_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq_window_size</key><value>10</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sig_window_size</key><value>10</value></param>
</block>
<block>
<key>digitizers_picoscope_3000a</key>
<param><key>id</key><value>digitizers_picoscope_3000a_0</value></param>
<param><key>acquisition_mode</key><value>Streaming</value></param>
<param><key>enable_ai_a</key><value>True</value></param>
<param><key>enable_ai_b</key><value>False</value></param>
<param><key>enable_ai_c</key><value>False</value></param>
<param><key>enable_ai_d</key><value>False</value></param>
<param><key>coupling_ai_a</key><value>True</value></param>
<param><key>coupling_ai_b</key><value>False</value></param>
<param><key>coupling_ai_c</key><value>False</value></param>
<param><key>coupling_ai_d</key><value>False</value></param>
<param><key>downsampling_factor</key><value>16</value></param>
<param><key>downsampling_mode</key><value>0</value></param>
<param><key>buff_size</key><value>100000</value></param>
<param><key>nr_waveforms</key><value>5</value></param>
<param><key>pin_number</key><value>0</value></param>
<param><key>poll_rate</key><value>0.0005</value></param>
<param><key>thresh_di_0</key><value>0.5</value></param>
<param><key>enable_di_0</key><value>False</value></param>
<param><key>thresh_di_1</key><value>2.5</value></param>
<param><key>enable_di_1</key><value>False</value></param>
<param><key>samples</key><value>10000</value></param>
<param><key>pre_samples</key><value>5000</value></param>
<param><key>range_ai_a</key><value>5</value></param>
<param><key>range_ai_b</key><value>5</value></param>
<param><key>range_ai_c</key><value>5</value></param>
<param><key>range_ai_d</key><value>5.0</value></param>
<param><key>offset_ai_a</key><value>0.0</value></param>
<param><key>offset_ai_b</key><value>0.0</value></param>
<param><key>offset_ai_c</key><value>5.0</value></param>
<param><key>offset_ai_d</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>serial_number</key><value>FP635/008</value></param>
<param><key>trigger_direction</key><value>0</value></param>
<param><key>trigger_once</key><value>False</value></param>
<param><key>trigger_source</key><value>None</value></param>
<param><key>trigger_threshold</key><value>2.5</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>Approx. fq</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>blocks_uchar_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_block_aggregation_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_block_aggregation_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_block_demux_0</source_block_id><sink_block_id>blocks_uchar_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_block_spectral_peaks_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_freq_estimator_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>digitizers_block_aggregation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>digitizers_block_spectral_peaks_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>digitizers_freq_estimator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>4</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>6</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>digitizers_block_aggregation_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>3</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>5</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>7</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>blocks_uchar_to_float_0</sink_block_id><source_key>8</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_3000a_0</source_block_id><sink_block_id>digitizers_block_demux_0</sink_block_id><source_key>8</source_key><sink_key>0</sink_key></connection>
</flow_graph>
