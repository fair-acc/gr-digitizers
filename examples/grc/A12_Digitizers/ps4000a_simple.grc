<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_tag_object</key>
<param><key>id</key><value>beam_in_tag</value></param>
<param><key>key</key><value>pmt.intern("beam_in")</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>src</key><value>pmt.intern("src")</value></param>
<param><key>value</key><value>pmt.intern("value")</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>20000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>up_fq</value></param>
<param><key>value</key><value>50</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>samp_rate/2</value></param>
</block>
<block>
<key>digitizers_picoscope_4000a</key>
<param><key>id</key><value>digitizers_picoscope_4000a_0</value></param>
<param><key>acquisition_mode</key><value>Streaming</value></param>
<param><key>enable_ai_a</key><value>True</value></param>
<param><key>enable_ai_b</key><value>False</value></param>
<param><key>enable_ai_c</key><value>False</value></param>
<param><key>enable_ai_d</key><value>False</value></param>
<param><key>enable_ai_e</key><value>False</value></param>
<param><key>enable_ai_f</key><value>False</value></param>
<param><key>enable_ai_g</key><value>False</value></param>
<param><key>enable_ai_h</key><value>False</value></param>
<param><key>coupling_ai_a</key><value>True</value></param>
<param><key>coupling_ai_b</key><value>False</value></param>
<param><key>coupling_ai_c</key><value>False</value></param>
<param><key>coupling_ai_d</key><value>False</value></param>
<param><key>coupling_ai_e</key><value>False</value></param>
<param><key>coupling_ai_f</key><value>False</value></param>
<param><key>coupling_ai_g</key><value>False</value></param>
<param><key>coupling_ai_h</key><value>False</value></param>
<param><key>downsampling_factor</key><value>16</value></param>
<param><key>downsampling_mode</key><value>0</value></param>
<param><key>buff_size</key><value>100000</value></param>
<param><key>nr_waveforms</key><value>5</value></param>
<param><key>poll_rate</key><value>0.0005</value></param>
<param><key>samples</key><value>10000</value></param>
<param><key>pre_samples</key><value>5000</value></param>
<param><key>range_ai_a</key><value>5</value></param>
<param><key>range_ai_b</key><value>5</value></param>
<param><key>range_ai_c</key><value>5.0</value></param>
<param><key>range_ai_d</key><value>5.0</value></param>
<param><key>range_ai_e</key><value>5</value></param>
<param><key>range_ai_f</key><value>5</value></param>
<param><key>range_ai_g</key><value>5.0</value></param>
<param><key>range_ai_h</key><value>5.0</value></param>
<param><key>offset_ai_a</key><value>0.0</value></param>
<param><key>offset_ai_b</key><value>0.0</value></param>
<param><key>offset_ai_c</key><value>5.0</value></param>
<param><key>offset_ai_d</key><value>0.0</value></param>
<param><key>offset_ai_e</key><value>0.0</value></param>
<param><key>offset_ai_f</key><value>0.0</value></param>
<param><key>offset_ai_g</key><value>5.0</value></param>
<param><key>offset_ai_h</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>serial_number</key><value>EW413/152</value></param>
<param><key>trigger_direction</key><value>0</value></param>
<param><key>trigger_once</key><value>False</value></param>
<param><key>trigger_source</key><value>None</value></param>
<param><key>trigger_threshold</key><value>2.5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitizers_picoscope_4000a_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
</flow_graph>
