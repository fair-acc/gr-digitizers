options:
  parameters:
    author: p01900
    generate_options: qt_gui
    id: zmq_source_testing
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://10.0.0.2:5001
    timeout: '100'
    type: float
  states: {}
- name: zeromq_sub_source_0_0
  id: zeromq_sub_source
  parameters:
    address: tcp://10.0.0.2:5002
    timeout: '100'
    type: float
  states: {}

connections:
- [zeromq_sub_source_0, '0', qtgui_time_sink_x_0, '0']
- [zeromq_sub_source_0_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
