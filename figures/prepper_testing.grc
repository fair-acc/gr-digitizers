options:
  parameters:
    author: gsi
    category: '[my_Blocks]'
    generate_options: hb
    id: prep_new_testing
    output_language: python
    title: prepper testing
  states: {}

blocks:
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '55'
    offset: '0'
    phase: '0'
    samp_rate: out_samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '55'
    offset: '0'
    phase: '0'
    samp_rate: out_samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: bp_decimation
    gain: bp_gain
    high_cutoff_freq: bp_high_cut
    interp: bp_decimation
    low_cutoff_freq: bp_low_cut
    samp_rate: in_samp_rate
    type: fir_filter_fff
    width: bp_trans
    win: window.WIN_HANN
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: bp_decimation
    gain: bp_gain
    high_cutoff_freq: bp_high_cut
    low_cutoff_freq: bp_low_cut
    samp_rate: in_samp_rate
    type: fir_filter_fff
    width: bp_trans
    win: window.WIN_HANN
  states: {}
- name: blocks_divide_xx_1
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_1_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2.5'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_2
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_transcendental_0
  id: blocks_transcendental
  parameters:
    name: atan
    type: float
  states: {}
- name: blocks_transcendental_0_0
  id: blocks_transcendental
  parameters:
    name: atan
    type: float
  states: {}
- name: bp_decimation
  id: parameter
  parameters:
    label: band pass decimation
    type: intx
    value: '20'
  states: {}
- name: bp_gain
  id: parameter
  parameters:
    label: band pass gain
    type: eng_float
    value: '1'
  states: {}
- name: bp_high_cut
  id: parameter
  parameters:
    label: band pass high cutoff frequency
    type: eng_float
    value: '80'
  states: {}
- name: bp_low_cut
  id: parameter
  parameters:
    label: band pass low cutoff frequency
    type: eng_float
    value: '20'
  states: {}
- name: bp_trans
  id: parameter
  parameters:
    label: band pass transition width
    type: eng_float
    value: '10'
  states: {}
- name: in_samp_rate
  id: parameter
  parameters:
    label: incoming sample rate
    type: eng_float
    value: '200000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lp_cut
    decim: lp_decimation
    gain: lp_gain
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: lp_trans
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lp_cut
    decim: lp_decimation
    gain: lp_gain
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: lp_trans
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: lp_cut
    decim: lp_decimation
    gain: lp_gain
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: lp_trans
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_2
  id: low_pass_filter
  parameters:
    cutoff_freq: lp_cut
    decim: lp_decimation
    gain: lp_gain
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: lp_trans
    win: window.WIN_HAMMING
  states: {}
- name: lp_cut
  id: parameter
  parameters:
    label: low pass cutoff frequency
    type: eng_float
    value: '60'
  states: {}
- name: lp_decimation
  id: parameter
  parameters:
    label: low pass decimation
    type: intx
    value: '1'
  states: {}
- name: lp_gain
  id: parameter
  parameters:
    label: low pass gain
    type: eng_float
    value: '1'
  states: {}
- name: lp_trans
  id: parameter
  parameters:
    label: low pass transition width
    type: eng_float
    value: '10'
  states: {}
- name: out_samp_rate
  id: parameter
  parameters:
    label: outgoing sample rate
    type: eng_float
    value: '10000'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: Raw voltage
    type: float
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: Raw current
    type: float
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: Band Pass Voltage
    type: float
  states: {}
- name: pad_sink_2_0
  id: pad_sink
  parameters:
    label: Band pass current
    type: float
  states: {}
- name: pad_sink_3
  id: pad_sink
  parameters:
    label: Delta phase PHI
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: Voltage
    type: float
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: Current
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_2, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_1, '1']
- [band_pass_filter_0, '0', blocks_multiply_xx_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0_1, '0']
- [band_pass_filter_0, '0', pad_sink_2, '0']
- [band_pass_filter_0_0, '0', blocks_multiply_xx_0_0, '0']
- [band_pass_filter_0_0, '0', blocks_multiply_xx_0_2, '0']
- [band_pass_filter_0_0, '0', pad_sink_2_0, '0']
- [blocks_divide_xx_1, '0', blocks_transcendental_0, '0']
- [blocks_divide_xx_1_0, '0', blocks_transcendental_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', band_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', pad_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', band_pass_filter_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', pad_sink_1, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_0_1, '0', low_pass_filter_0_1, '0']
- [blocks_multiply_xx_0_2, '0', low_pass_filter_0_2, '0']
- [blocks_sub_xx_0, '0', pad_sink_3, '0']
- [blocks_transcendental_0, '0', blocks_sub_xx_0, '0']
- [blocks_transcendental_0_0, '0', blocks_sub_xx_0, '1']
- [low_pass_filter_0, '0', blocks_divide_xx_1, '0']
- [low_pass_filter_0_0, '0', blocks_divide_xx_1_0, '1']
- [low_pass_filter_0_1, '0', blocks_divide_xx_1, '1']
- [low_pass_filter_0_2, '0', blocks_divide_xx_1_0, '0']
- [pad_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [pad_source_0_0, '0', blocks_multiply_const_vxx_0_0, '0']

metadata:
  file_format: 1
