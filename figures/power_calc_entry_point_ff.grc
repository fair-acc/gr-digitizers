options:
  parameters:
    author: neumann
    generate_options: hb
    id: power_calc_prepper_ff
    output_language: python
    title: power_calc_prepper_ff
  states: {}

blocks:
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '55'
    offset: '0'
    phase: '0'
    samp_rate: out_samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '55'
    offset: '0'
    phase: '0'
    samp_rate: out_samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: bp_decimantion
    gain: '1'
    high_cutoff_freq: bp_high_cut
    low_cutoff_freq: bp_low_cut
    samp_rate: in_samp_rate
    type: fir_filter_fff
    width: bp_trans
    win: window.WIN_HANN
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: bp_decimantion
    gain: '1'
    high_cutoff_freq: bp_high_cut
    low_cutoff_freq: bp_low_cut
    samp_rate: in_samp_rate
    type: fir_filter_fff
    width: bp_trans
    win: window.WIN_HANN
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: voltage_correction_factor
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: current_correction_factor
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_2
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_transcendental_0
  id: blocks_transcendental
  parameters:
    name: atan
    type: float
  states: {}
- name: blocks_transcendental_0_0
  id: blocks_transcendental
  parameters:
    name: atan
    type: float
  states: {}
- name: bp_decimantion
  id: parameter
  parameters:
    label: band pass decimantion
    type: intx
    value: '20'
  states: {}
- name: bp_high_cut
  id: parameter
  parameters:
    label: band pass high cutoff frequency
    type: eng_float
    value: '80'
  states: {}
- name: bp_low_cut
  id: parameter
  parameters:
    label: band pass low cutoff frequency
    type: eng_float
    value: '20'
  states: {}
- name: bp_trans
  id: parameter
  parameters:
    label: band pass transition width
    type: eng_float
    value: '10'
  states: {}
- name: current_correction_factor
  id: parameter
  parameters:
    label: Current Correction Factor
    type: eng_float
    value: '2.5'
  states: {}
- name: in_samp_rate
  id: parameter
  parameters:
    label: in-coming samp rate
    type: eng_float
    value: '2000000'
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimantion
    gain: '1'
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimantion
    gain: '1'
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimantion
    gain: '1'
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_2
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimantion
    gain: '1'
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: lp_decimantion
  id: parameter
  parameters:
    label: low pass decimantion
    type: intx
    value: '1'
  states: {}
- name: out_samp_rate
  id: parameter
  parameters:
    label: out-going samp rate
    type: eng_float
    value: '100000'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: Delta phase PHI
    type: float
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: Band pass current
    type: float
  states: {}
- name: pad_sink_0_0_0
  id: pad_sink
  parameters:
    label: Band pass voltage
    type: float
  states: {}
- name: pad_sink_0_0_1
  id: pad_sink
  parameters:
    label: Raw current
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_0_1_0
  id: pad_sink
  parameters:
    label: Raw voltage
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: Current
    type: float
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: Voltage
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: bp_decimantion
    interp: '1'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: bp_decimantion
    interp: '1'
    type: fff
  states: {}
- name: voltage_correction_factor
  id: parameter
  parameters:
    label: Voltage Correction Factor
    type: eng_float
    value: '100'
  states: {}

connections:
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_1, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_2, '1']
- [band_pass_filter_0, '0', blocks_multiply_xx_0_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0_2, '0']
- [band_pass_filter_0, '0', pad_sink_0_0, '0']
- [band_pass_filter_0_0, '0', blocks_multiply_xx_0, '0']
- [band_pass_filter_0_0, '0', blocks_multiply_xx_0_1, '0']
- [band_pass_filter_0_0, '0', pad_sink_0_0_0, '0']
- [blocks_divide_xx_0, '0', blocks_transcendental_0, '0']
- [blocks_divide_xx_0_0, '0', blocks_transcendental_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', band_pass_filter_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', band_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0_1, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0_1_0, '0']
- [blocks_multiply_xx_0_1, '0', low_pass_filter_0_1_1, '0']
- [blocks_multiply_xx_0_2, '0', low_pass_filter_0_1_2, '0']
- [blocks_sub_xx_0, '0', pad_sink_0, '0']
- [blocks_transcendental_0, '0', blocks_sub_xx_0, '0']
- [blocks_transcendental_0_0, '0', blocks_sub_xx_0, '1']
- [low_pass_filter_0_1, '0', blocks_divide_xx_0, '0']
- [low_pass_filter_0_1_0, '0', blocks_divide_xx_0_0, '1']
- [low_pass_filter_0_1_1, '0', blocks_divide_xx_0, '1']
- [low_pass_filter_0_1_2, '0', blocks_divide_xx_0_0, '0']
- [pad_source_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [pad_source_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', pad_sink_0_0_1_0, '0']
- [rational_resampler_xxx_0_0, '0', pad_sink_0_0_1, '0']

metadata:
  file_format: 1
